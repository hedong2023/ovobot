# Repository hedong2023/ovobot

## KiCad design XCS-03A/cleanrobot-square-baro/cleanrobot-square-baro.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
D1: LED_Dual_Red_Blue; LED_Dual_1.6x1.5mm
J1: Conn_01x05_2mm; PinSocket_1x05_P2.00mm_Vertical
J2: ZH1.5MM/10ASMD; JST_ZH_B10B-ZR-SM4-TF_1x10-1MP_P1.50mm_Vertical
R1, R2: 10K; R_0603_1608Metric
SW1: SS12D10; SW_SS12D10_SPDT_H5mm
U1: HP203B; HOPERF_LGA-8_3.8x3.6mm_P0.9mm

Connections:
+3V3: C1.1, D1.1 (A1), D1.3 (A2), J1.1, J2.2, R1.1, R2.1, U1.3 (VDD)
/LED_BLUE: D1.4 (K2), J2.7
/LED_RED: D1.2 (K1), J2.8
/PW_SW: J2.3, SW1.2 (B)
/SCL1: J2.10, R2.2, U1.5 (SCL)
/SDA1: J2.9, R1.2, U1.6 (SDA)
/SWCLK: J1.4, J2.4
/SWDIO: J1.2, J2.5
/UART2_RX: J1.5, J2.6
GND: C1.2, J1.3, J2.1, SW1.1 (A), U1.2 (GND), U1.8 (CSB)

Board: 2 copper layers, 85.0 x 16.8 mm, 8 parts (1 on the bottom side), 10 nets.

## KiCad design XCS-03A/cleanrobot-square-main/cleanrobot-square-main.kicad_pcb

Parts:
C38, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51: 0.1uF; C_0603_1608Metric
C39: 10nF; C_0603_1608Metric
C52, C54, C65: 100uF/35V; CP_Elec_6.3x5.4
D8: 1N4004; D_SMA
J3: XH2.54MM/3A; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4, J5: PH2.0MM/5ASMT; JST_PH_B5B-PH-SM4-TB_1x05-1MP_P2.00mm_Vertical
L4, L5, L6, L7: 600R@100MHz/3A; L_1206_3216Metric
Q11: SS8050; SOT-23
R26: 4.7K/1%; R_0603_1608Metric
R27: 3.3K/1%; R_0603_1608Metric
R28, R43, R44, R45, R92: 10K/1%; R_0603_1608Metric
R31, R32, R33, R36: 0.1R; R_0805_2012Metric
R34, R35: 0.033R/1%(1W); R_1206_3216Metric
R37, R38, R39: 15K/1%; R_0603_1608Metric
R40, R41, R42: 51K/1%; R_0603_1608Metric
R46: 2K/1%; R_0603_1608Metric
R91: 1K/1%; R_0603_1608Metric
R93: 0R; R_0603_1608Metric
TP20: FAN_OUT; TestPoint_Pad_D1.0mm
TP21: FAN_OUT_N; TestPoint_Pad_D1.0mm
TP22: VDD; TestPoint_Pad_D1.0mm
TP23: MOTOR_LEFT_P; TestPoint_Pad_D1.0mm
TP24: MOTOR_LEFT_N; TestPoint_Pad_D1.0mm
TP25: MOTOR_RIGHT_P; TestPoint_Pad_D1.0mm
TP26: MOTOR_RIGHT_N; TestPoint_Pad_D1.0mm
TP69, TP74: 3.3V; TestPoint_Pad_D1.0mm
TP70, TP75: SPEED_LEFT; TestPoint_Pad_D1.0mm
TP71, TP76: GND; TestPoint_Pad_D1.0mm
U12, U13: DRV8870DDAR; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
U14, U15: LMV358TP-SR; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C47.1, C48.1, R45.1, U14.8 (V+), U15.8 (V+); also elsewhere on the board
+3V3: C50.1, C51.1, J4.3, J5.3, R26.1, R43.1, R44.1, TP69.1, TP74.1; also elsewhere on the board
+5V: R28.2; also elsewhere on the board
/driver/MOTOR_LEFT_N: J4.2, L5.2, TP24.1
/driver/MOTOR_LEFT_P: J4.1, L4.2, TP23.1
/driver/MOTOR_RIGHT_N: J5.2, L7.2, TP26.1
/driver/MOTOR_RIGHT_P: J5.1, L6.2, TP25.1
/driver/VREF55: C38.1, C39.1, U14.3 (+), U14.6 (-), U14.7, U15.3 (+), U15.5 (+)
ADC_FAN_MOTOR: C44.2, R40.2, U14.1; also elsewhere on the board
ADC_LEFT_MOTOR: C45.2, R41.2, U15.1; also elsewhere on the board
ADC_RIGHT_MOTOR: C46.2, R42.2, U15.7; also elsewhere on the board
GND: C38.2, C39.2, C41.2, C42.2, C43.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C54.2, C65.2, J4.5, J4.MP (MountPin), J5.5, J5.MP (MountPin), Q11.2 (E), R27.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R46.2, R92.1, TP71.1, TP76.1, U12.1 (GND), U12.9 (GND), U13.1 (GND), U13.9 (GND), U14.4 (V-), U15.4 (V-); also elsewhere on the board
unnamed: D8.2 (A), J3.2, R31.1, R32.1, R33.1, R36.1, R39.1, TP21.1
unnamed: J3.1, R93.1, TP20.1
unnamed: Q11.1 (B), R91.2, R92.2
unnamed: Q11.3 (C), R28.1, R93.2
unnamed: R34.1, R37.1, U12.7 (ISEN)
unnamed: L4.1, U12.6 (OUT1)
unnamed: L5.1, U12.8 (OUT2)
unnamed: C41.1, R26.2, R27.1, U12.4 (VREF), U13.4 (VREF)
unnamed: R35.1, R38.1, U13.7 (ISEN)
unnamed: L6.1, U13.6 (OUT1)
unnamed: L7.1, U13.8 (OUT2)
unnamed: C44.1, R39.2, R40.1, U14.2 (-)
unnamed: C49.1, R45.2, R46.1, U14.5 (+)
unnamed: C45.1, R37.2, R41.1, U15.2 (-)
unnamed: C46.1, R38.2, R42.1, U15.6 (-)
PWM_FAN: R91.1; also elsewhere on the board
PWM_LEFT1: U12.3 (IN1); also elsewhere on the board
PWM_LEFT2: U12.2 (IN2); also elsewhere on the board
PWM_RIGHT1: U13.3 (IN1); also elsewhere on the board
PWM_RIGHT2: U13.2 (IN2); also elsewhere on the board
SPEED_LEFT: J4.4, R43.2, TP70.1; also elsewhere on the board
SPEED_RIGHT: J5.4, R44.2, TP75.1; also elsewhere on the board
VDD: C42.1, C43.1, C52.1, C54.1, C65.1, D8.1 (K), J3.3, TP22.1, U12.5 (VM), U13.5 (VM); also elsewhere on the board

Parts:
AE1: Antenna_Shield; Texas_SWRA117D_2.4GHz_Left; not fitted
C1, C2: 22pF; C_0603_1608Metric; not fitted
C3, C5, C6, C7, C8, C10, C11, C15, C19, C21, C56: 0.1uF; C_0603_1608Metric
C4: 0.5pF; C_0603_1608Metric
C9, C17: 1uF; C_0603_1608Metric
C12: 1.2pF; C_0603_1608Metric
C13: 10nF; C_0603_1608Metric; not fitted
C14: 0.47uF; C_0603_1608Metric; not fitted
C16: 0.1uF; C_0603_1608Metric; not fitted
C18: 2.2uF; C_0603_1608Metric; not fitted
C20: 10nF; C_0603_1608Metric
C22: 2.2uF; C_0603_1608Metric
C57: 4.7uF; C_0603_1608Metric
L1: 3.3uH; L_0603_1608Metric
R1: 10K/1%; R_0603_1608Metric
R2: 510R; R_0603_1608Metric
R3: 1K/1%; R_0603_1608Metric
R4, R6, R7, R9: 0R; R_0603_1608Metric
R5, R8: 4.7K/1%; R_0603_1608Metric
TP1: DP; TestPoint_Pad_D1.0mm
TP2: DM; TestPoint_Pad_D1.0mm
TP3: 3V3; TestPoint_Pad_D1.0mm
TP4: GND; TestPoint_Pad_D1.0mm
U1: HS6220; SOIC-8_3.9x4.9mm_P1.27mm
U2: MM32F0163D7P; LQFP-64_10x10mm_P0.5mm
U3: BT3L; Tuya_BT3L
U4: MPU-6887; TDK_LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y; not fitted
U5: PMC131-S08A; SOIC-8_3.9x4.9mm_P1.27mm
U6: ICM-42670-N; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
Y1: 16MHz/22pF(10ppm); Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3.3VADC: C9.1, C11.1, C15.1, R9.2, U1.8 (VDD), U3.8 (VDD_BAT)
+3.3VP: C19.1, U5.1 (VDD); also elsewhere on the board
+3V3: C5.2, C6.2, C7.2, C8.2, C10.2, C13.2, C16.2, C17.1, C18.2, C20.2, C21.2, C22.2, C56.2, C57.2, R4.1, R4.2, R5.2, R8.2, R9.1, TP3.1, U2.1 (VDD), U2.13 (VDDA), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U4.1 (VDDIO), U4.5 (CS), U4.16 (VDD), U6.5 (VDDIO), U6.8 (VDD), U6.12 (CS); also elsewhere on the board
/main/BLE_MCU_RXD: R6.2, U2.59 (PB7)
/main/BLE_MCU_TXD: R7.2, U2.58 (PB6)
/main/MOSI: R3.1, U2.57 (PB5)
/main/SCK: U1.6 (SCK), U2.55 (PB3)
/main/SCS: U1.5 (CSN), U2.56 (PB4)
/main/TSD_DATA: U2.2 (PC13), U5.2 (PA6/X2)
/main/USB_DM: TP2.1, U2.44 (PA11)
/main/USB_DP: TP1.1, U2.45 (PA12)
ADC_FAN_MOTOR: U2.21 (PA5); also elsewhere on the board
ADC_LEFT_MOTOR: U2.14 (PA0); also elsewhere on the board
ADC_RIGHT_MOTOR: U2.15 (PA1); also elsewhere on the board
BATT_C: U5.6 (PA3/DD8/PWM1); also elsewhere on the board
BATT_V: U5.7 (PA4/AD9/INT1A); also elsewhere on the board
BELL: U2.54 (PD2); also elsewhere on the board
CHG_PWM: U5.4 (PB7/AD7/PWM2); also elsewhere on the board
CHG_V: U2.11 (PC3); also elsewhere on the board
COLL_BTN_CP: U2.53 (PC12); also elsewhere on the board
COLL_BTN_IN: U2.51 (PC10); also elsewhere on the board
COLL_BTN_PL: U2.52 (PC11); also elsewhere on the board
EDGE_DET_LB: U2.36 (PB15); also elsewhere on the board
EDGE_DET_LT: U2.35 (PB14); also elsewhere on the board
EDGE_DET_RB: U2.33 (PB12); also elsewhere on the board
EDGE_DET_RT: U2.34 (PB13); also elsewhere on the board
GND: AE1.2 (Shield), C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.2, C12.1, C13.1, C14.1, C15.2, C16.1, C17.2, C18.1, C19.2, C20.1, C21.1, C22.1, C56.1, C57.1, R1.1, TP4.1, U1.3 (VSS), U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), U3.9 (GND), U3.17 (PAD), U4.4 (AD0/SDO), U4.9 (RESV), U4.10 (RESV), U4.11 (RESV), U4.12 (RESV), U4.13 (GND), U4.15 (RECV), U5.8 (GND), U6.1 (SDO/SA0), U6.2 (SDX), U6.3 (SCX), U6.6 (GND), U6.7 (GND), Y1.2, Y1.4; also elsewhere on the board
LED_BLUE: U2.24 (PC4); also elsewhere on the board
LED_GREEN: U5.5 (PB1/AD1/Vref); also elsewhere on the board
LED_RED: U2.25 (PC5); also elsewhere on the board
MPC_WATCHDOG: U5.3 (PA5/PRSTB); also elsewhere on the board
unnamed: AE1.1 (A), C4.2, L1.2
unnamed: C2.1, R2.2, Y1.1
unnamed: C12.2, L1.1, U1.4 (ANT)
unnamed: R3.2, U1.7 (DATA/MOSI)
unnamed: C1.1, U1.1 (XC1), Y1.3
unnamed: R2.1, U1.2 (XC2)
unnamed: R1.2, U2.60 (BOOT0)
unnamed: C3.2, U2.7 (NRST)
unnamed: R6.1, U3.16 (TL_B1)
unnamed: R7.1, U3.15 (TL_B7)
unnamed: C14.2, U4.14 (REGOUT)
PWM_FAN: U2.20 (PA4); also elsewhere on the board
PWM_LEFT1: U2.38 (PC7); also elsewhere on the board
PWM_LEFT2: U2.37 (PC6); also elsewhere on the board
PWM_RIGHT1: U2.39 (PC8); also elsewhere on the board
PWM_RIGHT2: U2.40 (PC9); also elsewhere on the board
SCL1: R5.1, U2.61 (PB8), U4.2 (SCL/SCLK), U6.13 (SCL)
SCL2: U2.29 (PB10); also elsewhere on the board
SDA1: R8.1, U2.62 (PB9), U4.3 (SDA/SDI), U6.14 (SDA)
SDA2: U2.30 (PB11); also elsewhere on the board
SOLENOID_VALVE: U2.4 (PC15); also elsewhere on the board
SPEED_LEFT: U2.27 (PB1); also elsewhere on the board
SPEED_RIGHT: U2.26 (PB0); also elsewhere on the board
START: U2.42 (PA9); also elsewhere on the board
SWCLK: U2.49 (PA14); also elsewhere on the board
SWDIO: U2.46 (PA13); also elsewhere on the board
UART2_RX: U2.50 (PA15); also elsewhere on the board
VOICE_DATA: U2.41 (PA8); also elsewhere on the board
WATER_DET: U2.17 (PA3); also elsewhere on the board
WATER_PUMP: U2.3 (PC14); also elsewhere on the board

Notes on the sheet:
TIM17_CH1 HC32: TIM4_CHB
TIM3_CH1~4 HC32: PCA_CH0~3
IO变更如下: TEMP WATER_DET CHG_V SPRAY_BACK SPRAY_FRONT TSD_DATA START VOICE_DATA SCS
ADC
TIM1_CH1, TIM1_CH2 HC32: TIM3_CH0A, TIM3_CH1A
STM32: TIM15_CH1, TIM15_CH2 MM32: TIM2_CH3, TIM2_CH4 HC32: TIM2_CHA, TIM2_CHB
UART2_TX
TIM14_CH1 HC32: TIM5_CHA
TIM16_CH1 HC32: TIM1_CHA
FACTORY
兼容单片机如下: STM32F070RBT6 MM32F0163D7P HC32F072KATA

Parts:
BZ1: 85dB/5V; Buzzer_12x9.5RM7.6
C58: 0.1uF; C_0603_1608Metric
C59: 10uF; C_0603_1608Metric
C60: 1nF; C_0603_1608Metric
C61, C63, C64: 1uF; C_0603_1608Metric
C62: 0.39uF; C_0603_1608Metric
D10: SS14; D_SOD-123
J8, J12, J13: ZH1.5MM/6ASMT; JST_ZH_B6B-ZR-SM4-TF_1x06-1MP_P1.50mm_Vertical
J9: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical
J10, J11: ZH1.5MM/8ASMT; JST_ZH_B8B-ZR-SM4-TF_1x08-1MP_P1.50mm_Vertical
J16: ZH1.5MM/10ASMT; JST_ZH_B10B-ZR-SM4-TF_1x10-1MP_P1.50mm_Vertical
J18: ZH1.5MM/2ASMT; JST_ZH_B2B-ZR-SM4-TF_1x02-1MP_P1.50mm_Vertical
Q4, Q7, Q10: SS8050; SOT-23
Q12: SS8550; SOT-23
R20, R21, R51, R52, R54, R57, R58, R63, R67, R70, R71, R74, R75, R76, R77, R78, R79, R83, R84, R95: 10K/1%; R_0603_1608Metric
R29, R30, R49, R50, R53, R55, R56, R94: 1K/1%; R_0603_1608Metric
R59, R60, R68, R69, R96: 330R; R_0603_1608Metric
R61: 0R; R_0603_1608Metric
TP6: SCL2; TestPoint_Pad_D1.0mm
TP7: SDA2; TestPoint_Pad_D1.0mm
TP9, TP67: 3V3; TestPoint_Pad_D1.0mm
TP10, TP59: RED; TestPoint_Pad_D1.0mm
TP11, TP60: BLUE; TestPoint_Pad_D1.0mm
TP12, TP17, TP18, TP31, TP33, TP34, TP36, TP38, TP42, TP44, TP46, TP48, TP68, TP72, TP73, TP77: GND; TestPoint_Pad_D1.0mm
TP19: POWER_SW; TestPoint_Pad_D1.0mm
TP35: BTN0; TestPoint_Pad_D1.0mm
TP37: BTN1; TestPoint_Pad_D1.0mm
TP39: BTN2; TestPoint_Pad_D1.0mm
TP41: BTN3; TestPoint_Pad_D1.0mm
TP43: BTN4; TestPoint_Pad_D1.0mm
TP45: BTN5; TestPoint_Pad_D1.0mm
TP47: BTN6; TestPoint_Pad_D1.0mm
TP49: BTN7; TestPoint_Pad_D1.0mm
TP50: SWCLK; TestPoint_Pad_D1.0mm
TP51: EDGE_DET_LT; TestPoint_Pad_D1.0mm
TP52: EDGE_DET_LT_OUT; TestPoint_Pad_D1.0mm
TP53: EDGE_DET_LB; TestPoint_Pad_D1.0mm
TP54: EDGE_DET_LB_OUT; TestPoint_Pad_D1.0mm
TP55: EDGE_DET_RT; TestPoint_Pad_D1.0mm
TP56: EDGE_DET_RT_OUT; TestPoint_Pad_D1.0mm
TP57: EDGE_DET_RB; TestPoint_Pad_D1.0mm
TP58: EDGE_DET_RB_OUT; TestPoint_Pad_D1.0mm
TP61: SWDIO; TestPoint_Pad_D1.0mm
TP62: UART2_RX; TestPoint_Pad_D1.0mm
TP63: GREEN; TestPoint_Pad_D1.0mm
TP64: START; TestPoint_Pad_D1.0mm
TP65: SPEAKER_P; TestPoint_Pad_D1.0mm
TP66: SPEAKER_N; TestPoint_Pad_D1.0mm
U16: 74HC165; TSSOP-16_4.4x5mm_P0.65mm
U17: WT588F02B-8S(XCS-03); SOIC-8_3.9x4.9mm_P1.27mm
U18: 8002A; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VP: Q12.2 (E), R95.1; also elsewhere on the board
+3V3: C58.1, C59.1, J8.5, J9.1, J16.2, R20.1, R21.1, R49.1, R50.1, R51.1, R52.1, R55.1, R56.1, R57.1, R58.1, R71.1, R74.1, R75.1, R76.1, R77.1, R78.1, R79.1, TP9.1, TP67.1, U16.16 (VCC), U17.6 (VDD); also elsewhere on the board
+5V: BZ1.1 (-), C64.1, D10.1 (K), U18.6 (VDD); also elsewhere on the board
/peripheral/BLUE: Q10.3 (C), R60.1, R69.1
/peripheral/GREEN: Q12.3 (C), R96.2
/peripheral/RED: Q4.3 (C), R59.1, R68.1
/peripheral/VOICE_BUSY: R63.1, U17.1 (PC2/CS)
BELL: R53.1; also elsewhere on the board
COLL_BTN_CP: U16.2 (CP); also elsewhere on the board
COLL_BTN_IN: U16.9 (Q7); also elsewhere on the board
COLL_BTN_PL: U16.1 (~PL); also elsewhere on the board
EDGE_DET_LB: J12.4, R52.2, TP53.1; also elsewhere on the board
EDGE_DET_LT: J12.1, R51.2, TP51.1; also elsewhere on the board
EDGE_DET_RB: J13.4, R58.2, TP57.1; also elsewhere on the board
EDGE_DET_RT: J13.1, R57.2, TP55.1; also elsewhere on the board
GND: C58.2, C59.2, C60.2, C61.2, C63.1, C64.2, J8.6, J8.MP (MountPin), J9.3, J10.1, J10.3, J10.5, J10.7, J10.MP (MountPin), J11.1, J11.3, J11.5, J11.7, J11.MP (MountPin), J12.2, J12.5, J12.MP (MountPin), J13.2, J13.5, J13.MP (MountPin), J16.1, J16.MP (MountPin), J18.MP (MountPin), Q4.2 (E), Q7.2 (E), Q10.2 (E), R54.2, R83.1, R84.1, TP12.1, TP17.1, TP18.1, TP31.1, TP33.1, TP34.1, TP36.1, TP38.1, TP42.1, TP44.1, TP46.1, TP48.1, TP68.1, TP72.1, TP73.1, TP77.1, U16.8 (GND), U16.10 (DS), U16.15 (~CE), U17.8 (GND), U18.7 (GND); also elsewhere on the board
LED_BLUE: R30.1; also elsewhere on the board
LED_GREEN: R94.1; also elsewhere on the board
LED_RED: R29.1; also elsewhere on the board
unnamed: BZ1.2 (+), D10.2 (A), Q7.3 (C)
unnamed: C62.2, R67.1
unnamed: J8.2, R96.1, TP63.1
unnamed: J8.3, R69.2, TP60.1
unnamed: J8.4, R68.2, TP59.1
unnamed: J10.2, R75.2, TP41.1, U16.14 (D3)
unnamed: J10.4, R74.2, TP39.1, U16.13 (D2)
unnamed: J10.6, R21.2, TP37.1, U16.12 (D1)
unnamed: J10.8, R20.2, TP35.1, U16.11 (D0)
unnamed: J11.2, R79.2, TP49.1, U16.6 (D7)
unnamed: J11.4, R78.2, TP47.1, U16.5 (D6)
unnamed: J11.6, R77.2, TP45.1, U16.4 (D5)
unnamed: J11.8, R76.2, TP43.1, U16.3 (D4)
unnamed: J12.3, R49.2, TP52.1
unnamed: J12.6, R50.2, TP54.1
unnamed: J13.3, R55.2, TP56.1
unnamed: J13.6, R56.2, TP58.1
unnamed: J16.7, R60.2, TP11.1
unnamed: J16.8, R59.2, TP10.1
unnamed: J18.1, TP66.1, U18.8 (VO2)
unnamed: J18.2, R70.2, TP65.1, U18.5 (VO1)
unnamed: Q4.1 (B), R29.2, R83.2
unnamed: Q7.1 (B), R53.2, R54.1
unnamed: Q10.1 (B), R30.2, R84.2
unnamed: Q12.1 (B), R94.2, R95.2
unnamed: R61.2, U17.2 (PC1/SO)
unnamed: C60.1, U17.5 (PWMN)
unnamed: C62.1, U17.7 (PWMP/DAC)
unnamed: C63.2, U18.2 (BYPASS), U18.3 (IN+)
unnamed: R67.2, R70.1, U18.4 (IN-)
unnamed: C61.1, R63.2, U18.1 (~SD)
POWER_SW: J16.3, TP19.1; also elsewhere on the board
SCL2: J16.10, TP6.1; also elsewhere on the board
SDA2: J16.9, TP7.1; also elsewhere on the board
START: J8.1, R71.2, TP64.1; also elsewhere on the board
SWCLK: J9.4, J16.4, TP50.1; also elsewhere on the board
SWDIO: J9.2, J16.5, TP61.1; also elsewhere on the board
UART2_RX: J9.5, J16.6, TP62.1; also elsewhere on the board
VOICE_DATA: R61.1; also elsewhere on the board

Parts:
C23, C66, C67, C68: 10uF; C_0603_1608Metric
C24, C37, C40, C69, C70, C72: 1uF; C_0603_1608Metric
C25, C26, C27, C28, C30, C32, C33, C34, C35: 0.1uF; C_0603_1608Metric
C29: 1nF; C_0603_1608Metric
C31, C55: 100uF/35V; CP_Elec_6.3x5.4
C36, C71: 10uF/35V; C_0805_2012Metric
C73: 3.3nF; C_0603_1608Metric
C74, C75: 470uF/10V; CP_Elec_6.3x7.7
D1: BAV99; SOT-23
D2: SMBJ26CA; D_SMB
D3, D4, D9: SS14; D_SOD-123
D5, D6, D7, D12: SS34; D_SMA
D11: SMAJ24CA; D_SMA
J1: VH3.96MM/2A; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J2: XHB2.54MM/3A; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L2: 100uH; L_GZJ_WNR6045
L3: 68uH; L_GZJ_CD75
Q1, Q9: SS8550; SOT-23
Q2: SS8050; SOT-23
Q3: NCE40P13S; SOIC-8_3.9x4.9mm_P1.27mm
Q8: HSS6107; SOT-23
R10, R15: 0.1R/1%; R_1206_3216Metric
R11, R13, R80: 1M/1%; R_0603_1608Metric
R12, R81: 100K/1%; R_0603_1608Metric
R14, R24, R87, R97: 1K/1%; R_0603_1608Metric
R16: 15K/1%; R_0603_1608Metric
R17, R18, R22, R23, R73, R85, R89, R90: 10K/1%; R_0603_1608Metric
R19: 51K/1%; R_0603_1608Metric
R25, R65, R72, R82: 100R; R_0603_1608Metric
R62, R64: 680R; R_0603_1608Metric
R66: 51R; R_0603_1608Metric
R86: 2K/1%; R_0603_1608Metric
R88: 0R; R_0603_1608Metric
R98: 3.9K/1%; R_0603_1608Metric
TP5, TP8: 24V; TestPoint_Pad_D1.0mm
TP13: TEMP; TestPoint_Pad_D1.0mm
TP14: BATT_SYS; TestPoint_Pad_D1.0mm
TP15: GND; TestPoint_Pad_D1.0mm
U7: LMV358TP-SR; SOIC-8_3.9x4.9mm_P1.27mm
U8: HT7533; SOT-89-3
U9: DS8562-33S5; SOT-23-5
U10: AMS1117-5.0; SOT-223-3_TabPin2
U11: XL1509-ADJ; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C70.1, R88.2; also elsewhere on the board
+3.3VP: C23.1, C32.1, C66.1, D1.2 (A), Q1.2 (E), Q9.2 (E), R13.2, R73.1, R85.1, R89.2, U7.8 (V+), U8.2 (VOUT); also elsewhere on the board
+3V3: C40.1, C69.1, R88.1, U9.5 (VOUT); also elsewhere on the board
+5V: C37.1, C68.1, C75.1, U9.1 (VIN), U9.3 (EN), U10.2 (VO); also elsewhere on the board
+6V: C67.1, C73.2, C74.1, L3.2, R98.2, U10.3 (VI); also elsewhere on the board
+24V: D2.1 (K), D3.2 (A), D5.2 (A), D6.2 (A), J1.1, TP5.1, TP8.1
+BATT: D7.2 (A), D9.1 (K), J2.1, R11.1, TP14.1
/power/BATT_NEG: J2.3, R10.2, R15.2, R16.1, TP15.1
/power/CHG_WATCHDOG: Q9.3 (C), R14.1, R90.2
BATT_C: C28.1, R65.2; also elsewhere on the board
BATT_V: C27.1, R25.2; also elsewhere on the board
CHG_PWM: Q2.2 (E); also elsewhere on the board
CHG_V: C34.1, R82.2; also elsewhere on the board
CHG_VREF55: C35.1, R85.2, R86.1, U7.3 (+)
GND: C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C40.2, C55.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C74.2, C75.2, D2.2 (A), D4.2 (A), D11.2 (A), D12.2 (A), J1.2, R10.1, R12.2, R15.1, R18.2, R81.2, R86.2, R90.1, R97.1, U7.4 (V-), U8.1 (GND), U9.2 (GND), U10.1 (GND), U11.4 (EN), U11.5 (GND), U11.6 (GND), U11.7 (GND), U11.8 (GND); also elsewhere on the board
MPC_WATCHDOG: R87.2; also elsewhere on the board
unnamed: C23.2, D1.1 (K), R13.1, R17.1
unnamed: C24.1, D1.3 (K)
unnamed: C24.2, R14.2
unnamed: C29.1, R72.2
unnamed: D4.1 (K), L2.1, Q8.3 (D), R72.1
unnamed: D5.1 (K), D6.1 (K), D7.1 (K), Q3.1 (S), Q3.2 (S), Q3.3 (S), R22.1
unnamed: C31.1, C33.1, D9.2 (A), L2.2
unnamed: D12.1 (K), L3.1, U11.2 (OUT)
unnamed: Q1.1 (B), R17.2
unnamed: Q1.3 (C), R18.1, R24.1
unnamed: Q2.1 (B), R24.2
unnamed: Q2.3 (C), R64.2
unnamed: Q3.4 (G), R22.2, R23.1
unnamed: Q8.1 (G), R66.1
unnamed: Q9.1 (B), R87.1, R89.1
unnamed: R19.2, R65.1, U7.1
unnamed: R62.2, R64.1, R66.2
unnamed: R80.2, R81.1, R82.1
unnamed: R16.2, R19.1, U7.2 (-)
unnamed: C25.1, R11.2, R12.1, U7.5 (+)
unnamed: R25.1, U7.6 (-), U7.7
unnamed: C73.1, R97.2, R98.1, U11.3 (FB)
POWER_SW: R23.2; also elsewhere on the board
TEMP: C30.1, J2.2, R73.2, TP13.1
VBUS: C26.1, C36.1, D3.1 (K), Q8.2 (S), R62.1, U8.3 (VIN)
VDD: C55.1, C71.1, C72.1, D11.1 (K), Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), R80.1, U11.1 (VIN); also elsewhere on the board

Notes on the sheet:
靠近单片机引脚
Vout=1.23(1+R86/R85)
