# Repository hedong2023/ovobot

## KiCad design ESMS-02/cleanrobot-square-led/cleanrobot-square-led.kicad_pcb

Board: 2 copper layers, 33.4 x 20.0 mm, 3 parts (1 on the bottom side), 7 nets.

Parts:
D1: LED_Dual_Red_Blue_AKAK; LED_Dual_1.6x1.5mm
J1: ZH1.5MM/7ASMD; JST_ZH_B7B-ZR-SM4-TF_1x07-1MP_P1.50mm_Vertical
J2: 1051330001; USB_Micro-B_Molex-105133-0001

Connections:
+3V3: D1.1 (A1), D1.3 (A2), J1.1, J2.1 (VBUS)
/BLUE: D1.4 (K2), J1.7
/RED: D1.2 (K1), J1.6
/SWCLK: J1.4, J2.3 (D+)
/SWDIO: J1.2, J2.2 (D-)
/UART2_RX: J1.5, J2.4 (ID)
GND: J1.3, J1.MP (MountPin), J2.5 (GND), J2.6 (Shield)

## KiCad design ESMS-02/cleanrobot-square-main/cleanrobot-square-main.kicad_pcb

Notes on the sheet:
Timer分配： STM32F030C8/HK32F030C8: TIM1(4) TIM3(4) TIM6(0) TIM14(1) TIM15(2)/16(1)/17(1) TIM1 (4 Channels) >>> 2个边轮马达驱动 TIM3 (2 Channels) >>> 2个边轮马达测速 TIM14 (1 Channel) >>> 风机马达 TIM15 (2 Channel) >>> 2路喷水 TIM6/16/17 >>> 定时中断 GD32E230C8: TIM0(4) TIM2(4) TIM5(0) TIM13(1)/14(2)/15(1)/16(1) TIM0 (4 Chann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

Parts:
FID1, FID2, FID3: NC/Fiducial; Fiducial_1mm_Mask2mm
J6: ZH1.5MM/7ASMT; JST_ZH_B7B-ZR-SM4-TF_1x07-1MP_P1.50mm_Vertical
J7: ZH1.5MM/5ASMT; JST_ZH_B5B-ZR-SM4-TF_1x05-1MP_P1.50mm_Vertical
J9: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical
J11, J12: ZH1.5MM/6ASMT; JST_ZH_B6B-ZR-SM4-TF_1x06-1MP_P1.50mm_Vertical
J13: ZH1.5MM/2ASMT; JST_ZH_B2B-ZR-SM4-TF_1x02-1MP_P1.50mm_Vertical
Q2, Q7, Q8: SS8050; SOT-23
R20, R21, R43, R68: 330R; R_0603_1608Metric
R49, R50, R55, R56: 120R; R_0603_1608Metric
R51, R52, R54, R57, R58, R62, R63, R71: 10K/1%; R_0603_1608Metric
R53, R60, R61: 1K; R_0603_1608Metric
TP6, TP19, TP20, TP21, TP22, TP45, TP46, TP47, TP53, TP54, TP55: GND; TestPoint_Pad_D1.0mm
TP7: LED_RED; TestPoint_Pad_D1.0mm
TP8, TP41: LED_BLUE; TestPoint_Pad_D1.0mm
TP9, TP43, TP44, TP48: +3V3; TestPoint_Pad_D1.0mm
TP10: EDGE_DET_LB_IR; TestPoint_Pad_D1.0mm
TP11: EDGE_DET_LT; TestPoint_Pad_D1.0mm
TP12: START; TestPoint_Pad_D1.0mm
TP13: EDGE_DET_LB; TestPoint_Pad_D1.0mm
TP14: EDGE_DET_LT_IR; TestPoint_Pad_D1.0mm
TP15: EDGE_DET_RT_IR; TestPoint_Pad_D1.0mm
TP16: EDGE_DET_RB; TestPoint_Pad_D1.0mm
TP17: EDGE_DET_RT; TestPoint_Pad_D1.0mm
TP18: EDGE_DET_RB_IR; TestPoint_Pad_D1.0mm
TP36: UART2_RX; TestPoint_Pad_D1.0mm
TP37: SWCLK; TestPoint_Pad_D1.0mm
TP38: SWDIO; TestPoint_Pad_D1.0mm
TP39: LED_RD; TestPoint_Pad_D1.0mm
TP40: BELL_N; TestPoint_Pad_D1.0mm
TP42: +5V; TestPoint_Pad_D1.0mm

Connections:
+3V3: J6.1, J7.3, J9.1, R49.1, R50.1, R51.1, R52.1, R55.1, R56.1, R57.1, R58.1, R71.1, TP9.1, TP43.1, TP44.1, TP48.1; also elsewhere on the board
+5V: J13.1, TP42.1; also elsewhere on the board
/peripheral/BLUE: Q8.3 (C), R21.1, R43.1
/peripheral/RED: Q2.3 (C), R20.1, R68.1
BELL: R53.1; also elsewhere on the board
EDGE_DET_LB: J11.1, R51.2, TP13.1; also elsewhere on the board
EDGE_DET_LT: J11.4, R52.2, TP11.1; also elsewhere on the board
EDGE_DET_RB: J12.4, R58.2, TP16.1; also elsewhere on the board
EDGE_DET_RT: J12.1, R57.2, TP17.1; also elsewhere on the board
GND: J6.3, J6.MP (MountPin), J7.1, J7.MP (MountPin), J9.3, J11.2, J11.5, J11.MP (MountPin), J12.2, J12.5, J12.MP (MountPin), J13.MP (MountPin), Q2.2 (E), Q7.2 (E), Q8.2 (E), R54.2, R62.2, R63.2, TP6.1, TP19.1, TP20.1, TP21.1, TP22.1, TP45.1, TP46.1, TP47.1, TP53.1, TP54.1, TP55.1; also elsewhere on the board
LED_BLUE: R61.1; also elsewhere on the board
LED_RED: R60.1; also elsewhere on the board
unnamed: J6.6, R20.2, TP39.1
unnamed: J6.7, R21.2, TP41.1
unnamed: J7.4, R68.2, TP7.1
unnamed: J7.5, R43.2, TP8.1
unnamed: J11.3, R49.2, TP10.1
unnamed: J11.6, R50.2, TP14.1
unnamed: J12.3, R55.2, TP15.1
unnamed: J12.6, R56.2, TP18.1
unnamed: J13.2, Q7.3 (C), TP40.1
unnamed: Q2.1 (B), R60.2, R62.1
unnamed: Q7.1 (B), R53.2, R54.1
unnamed: Q8.1 (B), R61.2, R63.1
START: J7.2, R71.2, TP12.1; also elsewhere on the board
SWCLK: J6.4, J9.4, TP37.1; also elsewhere on the board
SWDIO: J6.2, J9.2, TP38.1; also elsewhere on the board
UART2_RX: J6.5, J9.5, TP36.1; also elsewhere on the board

Parts:
C15, C20: 100uF/50V; CP_Elec_6.3x7.7
C21, C37: 10uF/35V; C_0805_2012Metric
C22, C25, C27, C32, C36: 1uF; C_0603_1608Metric
C24, C26, C29, C40: 0.1uF; C_0603_1608Metric
C30: 470pF; C_0603_1608Metric
C31: 220nF; C_0603_1608Metric
C33: 470uF/10V; CP_Elec_6.3x7.7
C34: 220pF; C_0603_1608Metric
C35: NC/1.5pF; C_0603_1608Metric
D1, D5, D6, D7: SS34; D_SMA
D2, D3: SS14; D_SOD-123
D15, D16: SMAJ24CA; D_SMA
J1: XH2.54MM/2A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: XH2.54MM/3A; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L1: 120R@100MHz/3A; L_1206_3216Metric
L2: 68uH; L_GZJ_CD75
L3: 100uH; L_GZJ_WNR6045
Q1: HSS6107; SOT-23
Q3: SS8050; SOT-23
Q10: NCE40P13S; SOIC-8_3.9x4.9mm_P1.27mm
R10: NC/10K; R_0603_1608Metric
R11, R13, R16, R18: 0R; R_0603_1608Metric
R12: 51R; R_0603_1608Metric
R14: 120R; R_0603_1608Metric
R15: NC/1.3M/1%; R_0603_1608Metric
R17: 5.1R; R_0603_1608Metric
R19: 0.5R/1%; R_1206_3216Metric
R24: 1M/1%; R_0603_1608Metric
R25: 100K/1%; R_0603_1608Metric
R72, R73, R76, R77, R78: 10K/1%; R_0603_1608Metric
R75: 1K; R_0603_1608Metric
TP49, TP50: +24V; TestPoint_Pad_D1.0mm
TP51: TEMP; TestPoint_Pad_D1.0mm
TP52: +BATT; TestPoint_Pad_D1.0mm
U7: RT9013-33; SOT-23-5
U9: CN3704; TSSOP-16_4.4x5mm_P0.65mm
U10: XL1509-5.0E1; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C36.1, R18.2; also elsewhere on the board
+3.3VP: R13.2; also elsewhere on the board
+3V3: C27.1, C32.1, R13.1, R18.1, R72.2, R73.2, U7.5 (VOUT); also elsewhere on the board
+5V: C22.1, C33.1, L2.2, U7.1 (VIN), U7.3 (EN), U10.3 (FB); also elsewhere on the board
+24V: C20.1, C24.1, C26.1, D5.2 (A), D6.2 (A), D15.1 (K), J1.1, Q1.2 (S), TP49.1, TP50.1, U9.15 (VCC)
+BATT: C35.1, C37.1, J2.3, Q10.1 (S), Q10.2 (S), Q10.3 (S), R15.1, R19.2, R77.2, TP52.1, U9.14 (BAT)
/power/TEMP: J2.2, R10.1, TP51.1, U9.6 (TEMP)
ADC_BATT: C40.1, R24.2, R25.1; also elsewhere on the board
BATT_ON: R75.2; also elsewhere on the board
CHG_DONE_LED: R73.1, U9.5 (~DONE); also elsewhere on the board
CHG_ON_LED: R72.1, U9.4 (~CHRG); also elsewhere on the board
GND: C15.2, C20.2, C21.2, C22.2, C24.2, C25.2, C27.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C36.2, C37.2, C40.2, D1.2 (A), D3.2 (A), D15.2 (A), D16.2 (A), J1.2, J2.1, Q3.2 (E), R10.2, R11.2, R16.2, R25.2, R76.1, U7.2 (GND), U9.2 (PGND), U9.3 (GND), U10.4 (EN), U10.5 (GND), U10.6 (GND), U10.7 (GND), U10.8 (GND); also elsewhere on the board
unnamed: C31.1, R14.2
unnamed: C34.1, R17.2
unnamed: D1.1 (K), L2.1, U10.2 (OUT)
unnamed: D2.2 (A), L1.2
unnamed: D2.1 (K), D3.1 (K), L3.1, R17.1
unnamed: D7.2 (A), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D)
unnamed: L1.1, Q1.3 (D)
unnamed: Q1.1 (G), R12.1
unnamed: Q3.1 (B), R75.1, R76.2
unnamed: Q3.3 (C), R78.1
unnamed: Q10.4 (G), R77.1, R78.2
unnamed: C30.1, U9.8 (COM1)
unnamed: R14.1, U9.9 (COM2)
unnamed: C29.1, U9.11 (COM3)
unnamed: L3.2, R19.1, U9.13 (CSP)
unnamed: R12.2, U9.16 (DRV)
unnamed: R11.1, U9.7 (EOC)
unnamed: C35.2, R15.2, R16.1, U9.10 (TEST)
unnamed: C26.2, U9.1 (VG)
VDD: C15.1, C21.1, C25.1, D5.1 (K), D6.1 (K), D7.1 (K), D16.1 (K), R24.1, U10.1 (VIN); also elsewhere on the board

Notes on the sheet:
CN3705 220K/1%

Parts:
C52: 470uF/10V; CP_Elec_6.3x7.7
C56, C57: 1uF; C_0603_1608Metric
C66, C67: 0.1uF; C_0603_1608Metric
F1: MF-PSMF050X; Fuse_0805_2012Metric
J8: PH2.0MM/4ASMT; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
Q5, Q6: CJ2310; SOT-23
R22, R23: 1K; R_0603_1608Metric
R47, R48: 10K/1%; R_0603_1608Metric
TP32: SPRAY_FRONT_N; TestPoint_Pad_D1.0mm
TP33: SPRAY_FRONT_P; TestPoint_Pad_D1.0mm
TP34: SPRAY_BACK_P; TestPoint_Pad_D1.0mm
TP35: SPRAY_BACK_N; TestPoint_Pad_D1.0mm

Connections:
+5V: F1.1; also elsewhere on the board
GND: C52.2, C56.2, C57.2, C66.2, C67.2, J8.MP (MountPin), Q5.2 (S), Q6.2 (S), R47.2, R48.2; also elsewhere on the board
unnamed: C52.1, C56.1, C57.1, C66.1, C67.1, F1.2, J8.1, J8.3, TP33.1, TP34.1
unnamed: J8.2, Q5.3 (D), TP32.1
unnamed: J8.4, Q6.3 (D), TP35.1
unnamed: Q5.1 (G), R22.2, R47.1
unnamed: Q6.1 (G), R23.2, R48.1
SPRAY_BACK: R23.1; also elsewhere on the board
SPRAY_FRONT: R22.1; also elsewhere on the board

Parts:
C38, C41, C42, C43, C44, C45, C46, C47, C48, C49: 0.1uF; C_0603_1608Metric
C39: 10nF; C_0603_1608Metric
C55, C58, C65: 100uF/50V; CP_Elec_6.3x7.7
D8: 1N4004; D_SMA
J4, J5: PH2.0MM/5ASMT; JST_PH_B5B-PH-SM4-TB_1x05-1MP_P2.00mm_Vertical
J14: PH2.0MM/4A; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
L4, L5, L6, L7: 120R@100MHz/3A; L_1206_3216Metric
Q4: SS8050; SOT-23
R26: 4.7K/1%; R_0603_1608Metric
R27: 3.3K/1%; R_0603_1608Metric
R28: 1K; R_0603_1608Metric
R29, R44, R45, R59: 10K/1%; R_0603_1608Metric
R30: NC/10K/1%; R_0603_1608Metric
R31, R32, R33, R36: 0.1R; R_0805_2012Metric
R34, R35: 0.033R/1%(1W); R_1206_3216Metric
R37, R38, R39: 15K/1%; R_0603_1608Metric
R40, R41, R42: 51K/1%; R_0603_1608Metric
R46: 2K/1%; R_0603_1608Metric
TP23: FAN_N; TestPoint_Pad_D1.0mm
TP24: FAN_P; TestPoint_Pad_D1.0mm
TP25: FAN_PWM; TestPoint_Pad_D1.0mm
TP26: SPEED_LEFT; TestPoint_Pad_D1.0mm
TP27: MOTOR_RIGHT_N; TestPoint_Pad_D1.0mm
TP28: MOTOR_RIGHT_P; TestPoint_Pad_D1.0mm
TP29: MOTOR_LEFT_N; TestPoint_Pad_D1.0mm
TP30: MOTOR_LEFT_P; TestPoint_Pad_D1.0mm
TP31: SPEED_RIGHT; TestPoint_Pad_D1.0mm
U12, U13: DRV8870DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
U14, U15: MCP6002-I/SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C47.1, C48.1, R45.1, U14.8 (V+), U15.8 (V+); also elsewhere on the board
+3V3: J4.1, J5.1, R26.1, R44.2, R59.2; also elsewhere on the board
/driver/VREF55: C38.1, C39.1, U14.3 (+), U14.6 (-), U14.7, U15.3 (+), U15.5 (+)
ADC_FAN_MOTOR: C44.2, R40.2, U14.1; also elsewhere on the board
ADC_LEFT_MOTOR: C45.2, R41.2, U15.1; also elsewhere on the board
ADC_RIGHT_MOTOR: C46.2, R42.2, U15.7; also elsewhere on the board
GND: C38.2, C39.2, C41.2, C42.2, C43.2, C47.2, C48.2, C49.2, C55.2, C58.2, C65.2, J4.3, J4.MP (MountPin), J5.3, J5.MP (MountPin), Q4.2 (E), R27.2, R29.1, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R46.2, U12.1 (GND), U12.9 (GND), U13.1 (GND), U13.9 (GND), U14.4 (V-), U15.4 (V-); also elsewhere on the board
unnamed: D8.2 (A), J14.3, R31.1, R32.1, R33.1, R36.1, R39.1, TP23.1
unnamed: J4.4, L5.2, TP29.1
unnamed: J4.5, L4.2, TP30.1
unnamed: J5.4, L7.2, TP27.1
unnamed: J5.5, L6.2, TP28.1
unnamed: J14.2, Q4.3 (C), R30.2, TP25.1
unnamed: Q4.1 (B), R28.2, R29.2
unnamed: R34.1, R37.1, U12.7 (ISEN)
unnamed: L4.1, U12.6 (OUT1)
unnamed: L5.1, U12.8 (OUT2)
unnamed: C41.1, R26.2, R27.1, U12.4 (VREF), U13.4 (VREF)
unnamed: R35.1, R38.1, U13.7 (ISEN)
unnamed: L6.1, U13.6 (OUT1)
unnamed: L7.1, U13.8 (OUT2)
unnamed: C44.1, R39.2, R40.1, U14.2 (-)
unnamed: C49.1, R45.2, R46.1, U14.5 (+)
unnamed: C45.1, R37.2, R41.1, U15.2 (-)
unnamed: C46.1, R38.2, R42.1, U15.6 (-)
PWM_FAN: R28.1; also elsewhere on the board
PWM_LEFT1: U12.3 (IN1); also elsewhere on the board
PWM_LEFT2: U12.2 (IN2); also elsewhere on the board
PWM_RIGHT1: U13.3 (IN1); also elsewhere on the board
PWM_RIGHT2: U13.2 (IN2); also elsewhere on the board
SPEED_LEFT: J4.2, R44.1, TP26.1; also elsewhere on the board
SPEED_RIGHT: J5.2, R59.1, TP31.1; also elsewhere on the board
VDD: C42.1, C43.1, C55.1, C58.1, C65.1, D8.1 (K), J14.4, R30.1, TP24.1, U12.5 (VM), U13.5 (VM); also elsewhere on the board

Parts:
AE1: NC/Antenna; Ovo_PA2401_2.4GHz_Right
C1, C2, C9: 1uF; C_0603_1608Metric
C3, C4, C5, C6, C7, C8, C11, C12, C17: 0.1uF; C_0603_1608Metric
C10: 4.7uF; C_0603_1608Metric
C13: 10nF; C_0603_1608Metric; not fitted
C14: 10nF; C_0603_1608Metric
C16: 0.1uF; C_0603_1608Metric; not fitted
C18: 2.2uF; C_0603_1608Metric; not fitted
C19: 0.47uF; C_0603_1608Metric
C23: 2.2uF; C_0603_1608Metric
R1, R64: 10K/1%; R_0603_1608Metric
R2, R3, R4, R6, R7: 0R; R_0603_1608Metric
R5, R8: 4.7K/1%; R_0603_1608Metric
R9: 10K/1%; R_0603_1608Metric; not fitted
TP1: RX; TestPoint_Pad_D1.0mm
TP2: SWD; TestPoint_Pad_D1.0mm
TP3: SWC; TestPoint_Pad_D1.0mm
TP4: 3V3; TestPoint_Pad_D1.0mm
TP5: GND; TestPoint_Pad_D1.0mm
U1: LT8920; TSSOP-16_4.4x5mm_P0.65mm
U2: MM32F0144C6P; LQFP-48_7x7mm_P0.5mm
U3: BT3L; Tuya_BT3L; not fitted
U4: MPU-6509; TDK_LGA-24_3x3mm_P0.4mm_LayoutBorder6x6y; not fitted
U5: XBTM03; Ovo_XBTM03
U6: PMS150C-U06(0xD407B2); SOT-23-6
U8: MPU-6887P; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y
Y1: 12MHz/22pF(10ppm); Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3.3VP: C2.1, C9.1, C11.1, R2.1, U3.8 (VDD_BAT), U5.3 (VDD), U5.4 (VDD); also elsewhere on the board
+3V3: C6.2, C7.2, C8.2, C10.2, C12.1, C13.2, C14.2, C16.2, C17.2, C18.2, C23.2, R4.2, R5.2, R8.2, R9.1, R64.1, TP4.1, U2.1 (VDD), U2.24 (VDD), U2.48 (VDD), U4.8 (VDDIO), U4.13 (VDD), U4.22 (nCS), U6.5 (VDD), U8.1 (VDDIO), U8.5 (CS), U8.16 (VDD); also elsewhere on the board
/main/BLE_MCU_RXD: R6.2, U2.43 (PB7)
/main/BLE_MCU_TXD: R7.2, U2.42 (PB6)
/main/MISO: U1.2 (MISO), U2.40 (PB4)
/main/MOSI: U1.1 (MOSI), U2.41 (PB5)
/main/RF_REST: U1.4 (~RST), U2.6 (PF1)
/main/SCK: U1.16 (SCK), U2.39 (PB3)
/main/SCS: U1.14 (SS), U2.3 (PC14)
/main/SWS: U5.11 (TL_SWS)
/main/TSD_DATA: U2.5 (PF0), U6.3 (PA6)
ADC_BATT: U2.17 (PA7); also elsewhere on the board
ADC_FAN_MOTOR: U2.11 (PA1); also elsewhere on the board
ADC_LEFT_MOTOR: U2.15 (PA5); also elsewhere on the board
ADC_RIGHT_MOTOR: U2.16 (PA6); also elsewhere on the board
BATT_ON: U2.33 (PA12); also elsewhere on the board
BELL: U2.20 (PB2); also elsewhere on the board
CHG_DONE_LED: U2.26 (PB13); also elsewhere on the board
CHG_ON_LED: U2.25 (PB12); also elsewhere on the board
EDGE_DET_LB: U2.28 (PB15); also elsewhere on the board
EDGE_DET_LT: U2.27 (PB14); also elsewhere on the board
EDGE_DET_RB: U2.36 (PF7); also elsewhere on the board
EDGE_DET_RT: U2.35 (PF6); also elsewhere on the board
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.2, C12.2, C13.1, C14.1, C16.1, C17.1, C18.1, C19.1, C23.1, R1.1, TP5.1, U1.15 (VSS), U2.8 (VSSA), U2.23 (VSS), U2.47 (VSS), U3.9 (GND), U3.17 (PAD), U4.9 (AD0/SDO), U4.11 (RESV), U4.18 (GND), U4.20 (RESV), U5.1 (GND), U5.2 (GND), U6.2 (GND), U8.4 (AD0/SDO), U8.9 (RESV), U8.10 (RESV), U8.11 (RESV), U8.12 (RESV), U8.13 (GND), U8.15 (RECV), Y1.2, Y1.4; also elsewhere on the board
LED_BLUE: U2.22 (PB11); also elsewhere on the board
LED_RED: U2.21 (PB10); also elsewhere on the board
unnamed: AE1.1 (A), R3.2
unnamed: R3.1, U1.9 (ANTB)
unnamed: C4.1, R2.2, U1.12 (LDO_IN)
unnamed: C1.1, U1.5 (LDO_OUT), U1.8 (PLL_VDD)
unnamed: U1.7 (XTALI), Y1.1
unnamed: U1.6 (XTALO), Y1.3
unnamed: R1.2, U2.44 (BOOT0)
unnamed: C3.2, R64.2, U2.7 (NRST)
unnamed: C5.2, R4.1, U2.9 (VDDA)
unnamed: R6.1, U3.16 (TL_B1), U5.20 (TL_C2/TXD)
unnamed: R7.1, U3.15 (TL_B7), U5.21 (TL_C3/RXD)
unnamed: R9.2, U6.6 (PA3)
unnamed: C19.2, U8.14 (REGOUT)
PWM_FAN: U2.14 (PA4); also elsewhere on the board
PWM_LEFT1: U2.29 (PA8); also elsewhere on the board
PWM_LEFT2: U2.30 (PA9); also elsewhere on the board
PWM_RIGHT1: U2.31 (PA10); also elsewhere on the board
PWM_RIGHT2: U2.32 (PA11); also elsewhere on the board
SCL1: R5.1, U2.45 (PB8), U4.23 (SCL/SCLK), U8.2 (SCL/SCLK)
SDA1: R8.1, U2.46 (PB9), U4.24 (SDA/SDI/SDIO), U8.3 (SDA/SDI)
SPEED_LEFT: U2.18 (PB0); also elsewhere on the board
SPEED_RIGHT: U2.19 (PB1); also elsewhere on the board
SPRAY_BACK: U2.13 (PA3); also elsewhere on the board
SPRAY_FRONT: U2.12 (PA2); also elsewhere on the board
START: U2.2 (PC13); also elsewhere on the board
SWCLK: TP3.1, U2.37 (PA14); also elsewhere on the board
SWDIO: TP2.1, U2.34 (PA13); also elsewhere on the board
UART2_RX: TP1.1, U2.38 (PA15); also elsewhere on the board
VOICE_DATA: U2.4 (PC15)
WATER_DET: U2.10 (PA0)

Notes on the sheet:
UART2_TX
FACTORY

Board: 2 copper layers, 110.0 x 56.0 mm, 240 parts (55 on the bottom side), 116 nets.
