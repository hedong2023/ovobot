# Repository hedong2023/ovobot

## KiCad design EDS-01/cleanrobot-square-baro/cleanrobot-square-baro.kicad_pcb

Board: 2 copper layers, 37.0 x 16.2 mm, 7 parts (6 on the bottom side), 5 nets.

Parts:
C1: 4.7uF; C_0603_1608Metric
J1: ZH1.5MM/4A; JST_ZH_B04B-ZR_1x04_P1.50mm_Vertical
R1, R2, R3, R4: 10K; R_0603_1608Metric
U1: HP203B; HOPERF_LGA-8_3.8x3.6mm_P0.9mm

Connections:
+3V3: C1.1, J1.1, R1.1, R2.1, R3.1, U1.3 (VDD)
/SCL1: J1.3, R2.2, U1.5 (SCL)
/SDA1: J1.2, R1.2, U1.6 (SDA)
GND: C1.2, J1.4, R4.1, U1.2 (GND)
unnamed: R3.2, R4.2, U1.8 (CSB)

## KiCad design EDS-01/cleanrobot-square-led/cleanrobot-square-led.kicad_pcb

Board: 2 copper layers, 22.0 x 28.0 mm, 5 parts (1 on the bottom side), 7 nets.

Parts:
D1: WHITE; LED_0603_1608Metric
D2: BLUE; LED_0603_1608Metric
D3: RED; LED_0603_1608Metric
D4: LED_Dual_Orange_Green_AKAK; LED_Dual_1.6x1.5mm
J1: ZH1.5MM/7A; JST_ZH_B07B-ZR_1x07_P1.50mm_Vertical

Connections:
+3V3: D1.2 (A), D2.2 (A), D3.2 (A), J1.1
unnamed: D1.1 (K), J1.4
unnamed: D2.1 (K), J1.3
unnamed: D3.1 (K), J1.2
unnamed: D4.1 (A1), D4.3 (A2), J1.7
unnamed: D4.2 (K1), J1.5
unnamed: D4.4 (K2), J1.6

## KiCad design EDS-01/cleanrobot-square-main/cleanrobot-square-main.kicad_pcb

Notes on the sheet:
Timer分配： STM32F030C8/HK32F030C8: TIM1(4) TIM3(4) TIM6(0) TIM14(1) TIM15(2)/16(1)/17(1) TIM1 (4 Channels) >>> 2个边轮马达驱动 TIM3 (2 Channels) >>> 2个边轮马达测速 TIM14 (1 Channel) >>> 风机马达 TIM15 (2 Channel) >>> 2路喷水 TIM6/16/17 >>> 定时中断 GD32E230C8: TIM0(4) TIM2(4) TIM5(0) TIM13(1)/14(2)/15(1)/16(1) TIM0 (4 Chann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

Parts:
BZ1: 85dB/5V; Buzzer_12x9.5RM7.6
C12, C58, C66, C67, C68, C69, C70, C71: 0.1uF; C_0603_1608Metric
C59: 10uF; C_0603_1608Metric
C60: 1nF; C_0603_1608Metric
C61, C63, C64: 1uF; C_0603_1608Metric
C62: 0.39uF; C_0603_1608Metric
D10: NC/SS14; D_SOD-123
D11: RED; LED_0603_1608Metric
D12: BLUE; LED_0603_1608Metric
D13: WHITE; LED_0603_1608Metric
J9, J10, J11, J12, J16: ZH1.5MM/4A; JST_ZH_B04B-ZR_1x04_P1.50mm_Vertical
J13: SH1.25MM/4A; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J14: ZH1.5MM/7A; JST_ZH_B07B-ZR_1x07_P1.50mm_Vertical
LS1: PH2.0MM/2A; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
Q7: SS8050; SOT-23
R9, R52, R55, R56, R68, R69: 330R; R_0603_1608Metric
R48, R49, R50, R51, R54, R63, R67, R70: 10K; R_0603_1608Metric
R53: 1K; R_0603_1608Metric
R57, R58: 4.7K; R_0603_1608Metric
R61: 0R; R_0603_1608Metric
TP6: START; TestPoint_Pad_D1.0mm
TP7: PW_SW; TestPoint_Pad_D1.0mm
TP8: GND; TestPoint_Pad_D1.0mm
TP9: +3V0; TestPoint_Pad_D1.0mm
TP12: SCL; TestPoint_Pad_D1.0mm
TP13: SDA; TestPoint_Pad_D1.0mm
TP14: BARO_SCL1; TestPoint_Pad_D1.0mm
TP15: BARO_SDA1; TestPoint_Pad_D1.0mm
TP16: BARO_SCL2; TestPoint_Pad_D1.0mm
TP17: BARO_SDA2; TestPoint_Pad_D1.0mm
TP18: WHITE; TestPoint_Pad_D1.0mm
TP19: CHG_ON; TestPoint_Pad_D1.0mm
TP20: CHG_DONE; TestPoint_Pad_D1.0mm
TP21: +24V; TestPoint_Pad_D1.0mm
TP22: BLUE; TestPoint_Pad_D1.0mm
TP23: RED; TestPoint_Pad_D1.0mm
TP24: +3V3; TestPoint_Pad_D1.0mm
TP25: VO1; TestPoint_Pad_D1.0mm
TP26: VO2; TestPoint_Pad_D1.0mm
U6: PCA9517A; TSSOP-8_3x3mm_P0.65mm
U16: PMC232-S14; SOIC-14_3.9x8.7mm_P1.27mm
U17: WT588F02B-8S; SOP-8_3.9x4.9mm_P1.27mm
U18: 8002A; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3V0: J13.1, TP9.1; also elsewhere on the board
+3V3: C12.1, C58.1, C59.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, D11.2 (A), D12.2 (A), D13.2 (A), J9.1, J10.1, J11.1, J12.1, J14.1, J16.1, R48.1, R49.1, R50.1, R51.1, R57.2, R58.2, TP24.1, U6.1 (VCCA), U6.8 (VCCB), U16.10 (VDD), U17.6 (VDD); also elsewhere on the board
+5V: BZ1.1 (-), C64.1, D10.1 (K), U18.6 (VDD); also elsewhere on the board
+24V: J14.7, TP21.1; also elsewhere on the board
/peripheral/BARO_SCL1: J9.3, J10.3, R48.2, TP14.1, U16.2 (PB0/AD0/INT1)
/peripheral/BARO_SCL2: J11.3, J12.3, R50.2, TP16.1, U16.4 (PB2/AD2)
/peripheral/BARO_SDA1: J9.2, J10.2, R49.2, TP15.1, U16.3 (PB1/AD1)
/peripheral/BARO_SDA2: J11.2, J12.2, R51.2, TP17.1, U16.6 (PB3/AD3)
/peripheral/SCL_E: J16.3, TP12.1, U6.2 (SCLA)
/peripheral/SDA_E: J16.2, TP13.1, U6.3 (SDAA)
/peripheral/VOICE_BUSY: R63.1, U17.1 (PC2/CS)
BELL: R53.1; also elsewhere on the board
CHG_DONE_LED: J14.6, TP20.1; also elsewhere on the board
CHG_ON_LED: J14.5, TP19.1; also elsewhere on the board
GND: C12.2, C58.2, C59.2, C60.2, C61.2, C63.1, C64.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, J9.4, J10.4, J11.4, J12.4, J13.4, J16.4, Q7.2 (E), R54.2, TP8.1, U6.4 (GND), U16.5 (GND), U17.8 (GND), U18.7 (GND); also elsewhere on the board
LED_BLUE: R55.1, R69.1; also elsewhere on the board
LED_RED: R52.1, R68.1; also elsewhere on the board
LED_WHITE: R9.1, R56.1; also elsewhere on the board
unnamed: BZ1.2 (+), D10.2 (A), Q7.3 (C)
unnamed: C60.1, U17.5 (PWMN)
unnamed: C61.1, R63.2, U18.1 (~SD)
unnamed: C62.1, U17.7 (PWMP/DAC)
unnamed: C62.2, R67.1
unnamed: C63.2, U18.2 (BYPASS), U18.3 (IN+)
unnamed: D11.1 (K), R52.2
unnamed: D12.1 (K), R55.2
unnamed: D13.1 (K), R56.2
unnamed: J14.2, R68.2, TP23.1
unnamed: J14.3, R69.2, TP22.1
unnamed: J14.4, R9.2, TP18.1
unnamed: LS1.1, R70.2, TP25.1, U18.5 (VO1)
unnamed: LS1.2, TP26.1, U18.8 (VO2)
unnamed: Q7.1 (B), R53.2, R54.1
unnamed: R61.2, U17.2 (PC1/SO)
unnamed: R67.2, R70.1, U18.4 (IN-)
PW_SW: J13.2, TP7.1; also elsewhere on the board
SCL2: R58.1, U6.7 (SCLB), U16.11 (PA6/X2); also elsewhere on the board
SDA2: R57.1, U6.6 (SDAB), U16.12 (PA7/X1); also elsewhere on the board
START: J13.3, TP6.1; also elsewhere on the board
VOICE_DATA: R61.1; also elsewhere on the board

Parts:
C20: 220uF/50V; CP_Elec_8x10
C21, C37, C55: 10uF/35V; C_0805_2012Metric
C22, C25, C27, C32, C36: 1uF; C_0603_1608Metric
C23, C28: NC/1uF; C_0603_1608Metric
C24, C26, C29, C40: 0.1uF; C_0603_1608Metric
C30: 470pF; C_0603_1608Metric
C31: 220nF; C_0603_1608Metric
C33, C57: 470uF/10V; CP_Elec_6.3x7.7
C34: 220pF; C_0603_1608Metric
C35: NC/1.5pF; C_0603_1608Metric
D1, D5, D6, D7: SS34; D_SMA
D2, D3, D4: SS14; D_SOD-123
J1: XHB2.54MM/2A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: XH2.54MM/3A; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
L1: 600R@100MHz/3A; L_1206_3216Metric
L2: 68uH; L_GZJ_CD75
L3: 100uH; L_GZJ_WNR6045
Q1: SI2309; SOT-23
Q2: SS8050; SOT-23
Q3: SI4435DDY; SOIC-8_3.9x4.9mm_P1.27mm
R10: NC/10K; R_0603_1608Metric
R11: OR; R_0603_1608Metric
R12: 51R; R_0603_1608Metric
R13, R16, R18: 0R; R_0603_1608Metric
R14: 120R; R_0603_1608Metric
R15: NC/1.3M/1%; R_0603_1608Metric
R17: 5.1R; R_0603_1608Metric
R19: 0.22R/1%; R_1206_3216Metric
R20, R22, R23, R72, R73: 10K; R_0603_1608Metric
R21: 1K; R_0603_1608Metric
R24: 1M/1%; R_0603_1608Metric
R25: 100K/1%; R_0603_1608Metric
U7: RT9013-33; SOT-23-5
U8: NC/RT9013-33; SOT-23-5
U9: CN3704; TSSOP-16_4.4x5mm_P0.65mm
U10: XL1509-5.0E1; SOP-8_3.9x4.9mm_P1.27mm
U11: HT7533-1-SOT89; SOT-89-3

Connections:
+3.3VA: C36.1, R18.2; also elsewhere on the board
+3.3VP: C28.1, R13.2, U8.5 (VOUT); also elsewhere on the board
+3V0: C57.1, U11.3 (VOUT); also elsewhere on the board
+3V3: C27.1, C32.1, R13.1, R18.1, U7.5 (VOUT); also elsewhere on the board
+5V: C22.1, C23.1, C33.1, L2.2, U7.1 (VIN), U7.3 (EN), U8.1 (VIN), U8.3 (EN), U10.3 (FB); also elsewhere on the board
+24V: C20.1, C24.1, C26.1, D5.2 (A), D6.2 (A), J1.1, Q1.2 (S), U9.15 (VCC); also elsewhere on the board
+BATT: C35.1, C37.1, D7.2 (A), J2.3, R15.1, R19.2, U9.14 (BAT)
/power/TEMP: J2.2, R10.1, U9.6 (TEMP)
ADC_BATT: C40.1, R24.2, R25.1; also elsewhere on the board
CHG_DONE_LED: R73.1; also elsewhere on the board
CHG_ON_LED: R72.1; also elsewhere on the board
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C36.2, C37.2, C40.2, C55.2, C57.2, D1.2 (A), D3.2 (A), J1.2, J2.1, Q2.2 (E), R10.2, R11.2, R16.2, R20.2, R25.2, U7.2 (GND), U8.2 (GND), U9.2 (PGND), U9.3 (GND), U10.4 (EN), U10.5 (GND), U10.6 (GND), U10.7 (GND), U10.8 (GND), U11.1 (GND); also elsewhere on the board
unnamed: C26.2, U9.1 (VG)
unnamed: C29.1, U9.11 (COM3)
unnamed: C30.1, U9.8 (COM1)
unnamed: C31.1, R14.2
unnamed: C34.1, R17.2
unnamed: C35.2, R15.2, R16.1, U9.10 (TEST)
unnamed: C55.1, D4.1 (K), U11.2 (VIN)
unnamed: D1.1 (K), L2.1, U10.2 (OUT)
unnamed: D2.1 (K), D3.1 (K), L3.1, R17.1
unnamed: D2.2 (A), L1.2
unnamed: L1.1, Q1.3 (D)
unnamed: L3.2, R19.1, U9.13 (CSP)
unnamed: Q1.1 (G), R12.1
unnamed: Q2.1 (B), R21.2
unnamed: Q2.3 (C), R23.2
unnamed: Q3.4 (G), R22.2, R23.1
unnamed: R11.1, U9.7 (EOC)
unnamed: R12.2, U9.16 (DRV)
unnamed: R14.1, U9.9 (COM2)
unnamed: R72.2, U9.4 (~CHRG)
unnamed: R73.2, U9.5 (~DONE)
PW_SW: R20.1, R21.1; also elsewhere on the board
VCC: D4.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), Q3.1 (S), Q3.2 (S), Q3.3 (S), R22.1
VDD: C21.1, C25.1, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), R24.1, U10.1 (VIN); also elsewhere on the board

Notes on the sheet:
CN3705 220K/1%

Parts:
C52, C53: 470uF/10V; CP_Elec_6.3x7.7
C54: 1uF; C_0603_1608Metric
C56: 0.1uF; C_0603_1608Metric
F1: MF-PSMF050X; Fuse_0805_2012Metric
J8: PH2.0MM/2A; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
L8: 10/500uH; L_WLJ_CD0805
Q5: SI2302; SOT-23
R47: 10K; R_0603_1608Metric
TP10: PUMP_P; TestPoint_Pad_D1.0mm
TP11: PUMP_N; TestPoint_Pad_D1.0mm

Connections:
+5V: F1.1; also elsewhere on the board
GND: C52.2, C53.2, C54.2, C56.2, Q5.2 (S), R47.2; also elsewhere on the board
unnamed: C52.1, C53.1, C54.1, C56.1, F1.2, L8.1
unnamed: J8.1, L8.2, Q5.3 (D), TP11.1
unnamed: J8.2, L8.3, TP10.1
SPRAY_FRONT: Q5.1 (G), R47.1; also elsewhere on the board

Parts:
C38, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51: 0.1uF; C_0603_1608Metric
C39: 10nF; C_0603_1608Metric
C65: 220uF/50V; CP_Elec_8x10
D8: 1N4004; D_SMA
J3: XH2.54MM/4A; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4, J5: PH2.0MM/2A; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J6, J7: ZH1.5MM/3A; JST_ZH_B03B-ZR_1x03_P1.50mm_Vertical
L4, L5, L6, L7: 600R@100MHz/3A; L_1206_3216Metric
Q4: SS8050; SOT-23
R26: 4.7K/1%; R_0603_1608Metric
R27: 3.3K/1%; R_0603_1608Metric
R28: 1K; R_0603_1608Metric
R29, R30, R43, R44: 10K; R_0603_1608Metric
R31, R32, R33, R36: 0.1R; R_0805_2012Metric
R34, R35, R59, R60: 0.1R/1%(1W); R_1206_3216Metric
R37, R38, R39: 15K/1%; R_0603_1608Metric
R40, R41, R42: 51K/1%; R_0603_1608Metric
R45: 10K/1%; R_0603_1608Metric
R46: 2K/1%; R_0603_1608Metric
U12, U13: DRV8870DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
U14, U15: MCP6002-I/SN; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C47.1, C48.1, R45.1, U14.8 (V+), U15.8 (V+); also elsewhere on the board
+3V3: C50.1, C51.1, J6.1, J7.1, R26.1, R43.1, R44.1; also elsewhere on the board
/driver/VREF55: C38.1, C39.1, U14.3 (+), U14.6 (-), U14.7, U15.3 (+), U15.5 (+)
ADC_FAN_MOTOR: C44.2, R40.2, U14.1; also elsewhere on the board
ADC_LEFT_MOTOR: C45.2, R41.2, U15.1; also elsewhere on the board
ADC_RIGHT_MOTOR: C46.2, R42.2, U15.7; also elsewhere on the board
GND: C38.2, C39.2, C41.2, C42.2, C43.2, C47.2, C48.2, C49.2, C50.2, C51.2, C65.2, J6.3, J7.3, Q4.2 (E), R27.2, R29.1, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R46.2, R59.2, R60.2, U12.1 (GND), U12.9 (GND), U13.1 (GND), U13.9 (GND), U14.4 (V-), U15.4 (V-); also elsewhere on the board
unnamed: C41.1, R26.2, R27.1, U12.4 (VREF), U13.4 (VREF)
unnamed: C44.1, R39.2, R40.1, U14.2 (-)
unnamed: C45.1, R37.2, R41.1, U15.2 (-)
unnamed: C46.1, R38.2, R42.1, U15.6 (-)
unnamed: C49.1, R45.2, R46.1, U14.5 (+)
unnamed: D8.2 (A), J3.2, J3.3, R31.1, R32.1, R33.1, R36.1, R39.1
unnamed: J3.4, Q4.3 (C), R30.2
unnamed: J4.1, L4.2
unnamed: J4.2, L5.2
unnamed: J5.1, L6.2
unnamed: J5.2, L7.2
unnamed: L4.1, U12.6 (OUT1)
unnamed: L5.1, U12.8 (OUT2)
unnamed: L6.1, U13.6 (OUT1)
unnamed: L7.1, U13.8 (OUT2)
unnamed: Q4.1 (B), R28.2, R29.2
unnamed: R34.1, R37.1, R59.1, U12.7 (ISEN)
unnamed: R35.1, R38.1, R60.1, U13.7 (ISEN)
PWM_FAN: R28.1; also elsewhere on the board
PWM_LEFT1: U12.3 (IN1); also elsewhere on the board
PWM_LEFT2: U12.2 (IN2); also elsewhere on the board
PWM_RIGHT1: U13.3 (IN1); also elsewhere on the board
PWM_RIGHT2: U13.2 (IN2); also elsewhere on the board
SPEED_LEFT: J6.2, R43.2; also elsewhere on the board
SPEED_RIGHT: J7.2, R44.2; also elsewhere on the board
VDD: C42.1, C43.1, C65.1, D8.1 (K), J3.1, R30.1, U12.5 (VM), U13.5 (VM); also elsewhere on the board

Parts:
AE1: Antenna; Ovo_PA2401_2.4GHz_Right
C1, C2, C9: 1uF; C_0603_1608Metric
C3, C4, C5, C6, C7, C8, C11, C16: 0.1uF; C_0603_1608Metric
C10: 4.7uF; C_0603_1608Metric
C13: 10nF; C_0603_1608Metric
C14: 0.47uF; C_0603_1608Metric
C15: NC/10nF; C_0603_1608Metric
C17: NC/0.1uF; C_0603_1608Metric
C18: 2.2uF; C_0603_1608Metric
C19: NC/2.2uF; C_0603_1608Metric
J15: ZH1.5MM/4A; JST_ZH_B04B-ZR_1x04_P1.50mm_Vertical
R1: 10K; R_0603_1608Metric
R2, R3, R4, R6, R7: 0R; R_0603_1608Metric
R5, R8: 4.7K; R_0603_1608Metric
TP1: RX; TestPoint_Pad_D1.0mm
TP2: SWD; TestPoint_Pad_D1.0mm
TP3: SWC; TestPoint_Pad_D1.0mm
TP4: 3V3; TestPoint_Pad_D1.0mm
TP5, TP28: GND; TestPoint_Pad_D1.0mm
TP27: +3.3VP; TestPoint_Pad_D1.0mm
TP29: TXD; TestPoint_Pad_D1.0mm
TP30: RXD; TestPoint_Pad_D1.0mm
U1: LT8920; TSSOP-16_4.4x5mm_P0.65mm
U2: STM32F030C8T6; LQFP-48_7x7mm_P0.5mm
U3: NC/BT3L; Tuya_BT3L
U4: MPU-6887; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y
U5: NC/LSM6DSR; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
Y1: 12MHz/22pF(10ppm); Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+3.3VP: C2.1, C9.1, C11.1, R2.1, TP27.1, U3.8 (VDD_BAT); also elsewhere on the board
+3V3: C6.2, C7.2, C8.2, C10.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, J15.1, R4.2, R5.2, R8.2, TP4.1, U2.1 (VDD), U2.24 (VDD), U2.48 (VDD), U4.1 (VDDIO), U4.5 (CS), U4.16 (VDD), U5.5 (VDDIO), U5.8 (VDD), U5.12 (CS); also elsewhere on the board
/main/BLE_MCU_RXD: R6.2, U2.43 (PB7)
/main/BLE_MCU_TXD: R7.2, U2.42 (PB6)
/main/MISO: U1.2 (MISO), U2.40 (PB4)
/main/MOSI: U1.1 (MOSI), U2.41 (PB5)
/main/RF_REST: U1.4 (~RST), U2.6 (PF1)
/main/SCK: U1.16 (SCK), U2.39 (PB3)
/main/SCS: U1.14 (SS), U2.5 (PF0)
ADC_BATT: U2.17 (PA7); also elsewhere on the board
ADC_FAN_MOTOR: U2.11 (PA1); also elsewhere on the board
ADC_LEFT_MOTOR: U2.15 (PA5); also elsewhere on the board
ADC_RIGHT_MOTOR: U2.16 (PA6); also elsewhere on the board
BELL: U2.20 (PB2); also elsewhere on the board
CHG_LED_SW: U2.33 (PA12)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, J15.3, R1.1, TP5.1, TP28.1, U1.15 (VSS), U2.8 (VSSA), U2.23 (VSS), U2.47 (VSS), U3.9 (GND), U4.4 (AD0/SDO), U4.9 (RESV), U4.10 (RESV), U4.11 (RESV), U4.12 (RESV), U4.13 (GND), U4.15 (RECV), U5.1 (SDO/SA0), U5.2 (SDX), U5.3 (SCX), U5.6 (GND), U5.7 (GND), Y1.2, Y1.4; also elsewhere on the board
LED_BLUE: U2.26 (PB13); also elsewhere on the board
LED_RED: U2.25 (PB12); also elsewhere on the board
LED_WHITE: U2.27 (PB14); also elsewhere on the board
unnamed: AE1.1 (A), R3.2
unnamed: C1.1, U1.5 (LDO_OUT), U1.8 (PLL_VDD)
unnamed: C3.2, U2.7 (NRST)
unnamed: C4.1, R2.2, U1.12 (LDO_IN)
unnamed: C5.2, R4.1, U2.9 (VDDA)
unnamed: C14.2, U4.14 (REGOUT)
unnamed: R1.2, U2.44 (BOOT0)
unnamed: R3.1, U1.9 (ANTB)
unnamed: R6.1, TP30.1, U3.16 (TL_B1)
unnamed: R7.1, TP29.1, U3.15 (TL_B7)
unnamed: U1.6 (XTALO), Y1.3
unnamed: U1.7 (XTALI), Y1.1
PWM_FAN: U2.14 (PA4); also elsewhere on the board
PWM_LEFT1: U2.29 (PA8); also elsewhere on the board
PWM_LEFT2: U2.30 (PA9); also elsewhere on the board
PWM_RIGHT1: U2.31 (PA10); also elsewhere on the board
PWM_RIGHT2: U2.32 (PA11); also elsewhere on the board
SCL1: R5.1, U2.45 (PB8), U4.2 (SCL/SCLK), U5.13 (SCL)
SCL2: U2.21 (PB10); also elsewhere on the board
SDA1: R8.1, U2.46 (PB9), U4.3 (SDA/SDI), U5.14 (SDA)
SDA2: U2.22 (PB11); also elsewhere on the board
SPEED_LEFT: U2.18 (PB0); also elsewhere on the board
SPEED_RIGHT: U2.19 (PB1); also elsewhere on the board
SPRAY_BACK: U2.13 (PA3)
SPRAY_FRONT: U2.12 (PA2); also elsewhere on the board
START: U2.2 (PC13); also elsewhere on the board
SWCLK: J15.4, TP3.1, U2.37 (PA14)
SWDIO: J15.2, TP2.1, U2.34 (PA13)
UART2_RX: TP1.1, U2.38 (PA15)
VOICE_DATA: U2.4 (PC15); also elsewhere on the board

Notes on the sheet:
UART2_TX
FACTORY

Board: 2 copper layers, 130.0 x 61.0 mm, 234 parts (33 on the bottom side), 125 nets.
