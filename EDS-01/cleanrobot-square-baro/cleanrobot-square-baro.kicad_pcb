# Repository hedong2023/ovobot (continued)

## KiCad design EDS-01/cleanrobot-square-switch/cleanrobot-square-switch.kicad_pcb

Board: 2 copper layers, 45.5 x 45.1 mm, 5 parts (4 on the bottom side), 5 nets.

Parts:
C1: 0.1uF; C_0603_1608Metric
J2: SH1.25MM/4A; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
R1: 10K/1%; R_0603_1608Metric
SW1: 5.7x3.7_Hmm; SW_Push_1P1T_NO_5.7x3.7mm_Hmm
U1: PMS150C-U06(0x2B191B); SOT-23-6

Connections:
+3.3V: C1.1, J2.1, R1.1, U1.5 (VDD)
/POWER_ON: J2.2, U1.1 (PA4)
/START: R1.2, SW1.1, U1.6 (PA3)
/TSD_DATA: J2.3, U1.3 (PA6)
GND: C1.2, J2.4, SW1.2, U1.2 (GND)

## KiCad design EGS-01/cleanrobot-square-baro/cleanrobot-square-baro.kicad_pcb

Board: 2 copper layers, 58.0 x 23.0 mm, 22 parts (11 on the bottom side), 10 nets.

Parts:
C1: 4.7uF; C_0603_1608Metric
C2: 0.1uF; C_0603_1608Metric
D1: RED; LED_0603_1608Metric
D2: BLUE; LED_0603_1608Metric
J1: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical
J2: GH1.25MM/11AWSMT; JST_GH_SM11B-GHS-TB_1x11-1MP_P1.25mm_Horizontal
R1, R2, R3: 10K/1%; R_0603_1608Metric
TP1: BLUE; TestPoint_Pad_D1.0mm
TP2: IR_OUT; TestPoint_Pad_D1.0mm
TP3: SCL; TestPoint_Pad_D1.0mm
TP4: WDIO1; TestPoint_Pad_D1.0mm
TP5: SDA; TestPoint_Pad_D1.0mm
TP6: SWCLK; TestPoint_Pad_D1.0mm
TP7: 3V3; TestPoint_Pad_D1.0mm
TP8: RED; TestPoint_Pad_D1.0mm
TP9: UART2_RX; TestPoint_Pad_D1.0mm
TP10, TP11: GND; TestPoint_Pad_D1.0mm
U1: RMW-H3638T-B; Everlight_IRM-3640CF45
U2: HP203B; HOPERF_LGA-8_3.8x3.6mm_P0.9mm

Connections:
+3V3: C1.1, C2.1, D1.2 (A), D2.2 (A), J1.1, J2.3, R1.1, R2.1, R3.1, TP7.1, U1.3 (VCC), U2.3 (VDD)
/BLUE: D2.1 (K), J2.5, TP1.1
/IR_OUT: J2.6, R3.2, TP2.1, U1.1 (OUT)
/RED: D1.1 (K), J2.4, TP8.1
/SCL1: J2.1, R2.2, TP3.1, U2.5 (SCL)
/SDA1: J2.2, R1.2, TP5.1, U2.6 (SDA)
/SWCLK: J1.4, J2.8, TP6.1
/SWDIO: J1.2, J2.7, TP4.1
/UART2_RX: J1.5, J2.9, TP9.1
GND: C1.2, C2.2, J1.3, J2.10, J2.11, J2.MP (MountPin), TP10.1, TP11.1, U1.2 (GND), U2.2 (GND), U2.8 (CSB)

## KiCad design EGS-01/cleanrobot-square-main/cleanrobot-square-main.kicad_pcb

Notes on the sheet:
Timer分配： STM32F030C8/HK32F030C8: TIM1(4) TIM3(4) TIM6(0) TIM14(1) TIM15(2)/16(1)/17(1) TIM1 (4 Channels) >>> 2个边轮马达驱动 TIM3 (2 Channels) >>> 2个边轮马达测速 TIM14 (1 Channel) >>> 风机马达 TIM15 (2 Channel) >>> 2路喷水 TIM6/16/17 >>> 定时中断 GD32E230C8: TIM0(4) TIM2(4) TIM5(0) TIM13(1)/14(2)/15(1)/16(1) TIM0 (4 Chann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

Parts:
BZ1: 85dB/5V; Buzzer_12x9.5RM7.6
J10: ZH1.5MM/7ASMT; JST_ZH_B7B-ZR-SM4-TF_1x07-1MP_P1.50mm_Vertical
J11: ZH1.5MM/6ASMT; JST_ZH_B6B-ZR-SM4-TF_1x06-1MP_P1.50mm_Vertical
J12: Conn_01x05; PinHeader_1x05_P2.00mm_Vertical
J13: GH1.25MM/11ASMT; JST_GH_BM11B-GHS-TBT_1x11-1MP_P1.25mm_Vertical
J14: GH1.25MM/10ASMT; JST_GH_BM10B-GHS-TBT_1x10-1MP_P1.25mm_Vertical
Q10, Q11, Q12: SS8050; SOT-23
R61, R65, R66, R67, R69, R71, R74, R77, R78, R80: 10K/1%; R_0603_1608Metric
R62, R63, R73, R81, R82: 1K/1%; R_0603_1608Metric
R64, R68, R70, R72: 470R; R_0603_1608Metric
R75, R76, R79: 330R; R_0603_1608Metric
R87, R88: 0R; R_0603_1608Metric
TP1, TP58: SWD; TestPoint_Pad_D1.0mm
TP2: SWC; TestPoint_Pad_D1.0mm
TP3: RX; TestPoint_Pad_D1.0mm
TP31: EDGE_DET_LB; TestPoint_Pad_D1.0mm
TP32: EDGE_DET_LB_OUT; TestPoint_Pad_D1.0mm
TP33: EDGE_DET_LT; TestPoint_Pad_D1.0mm
TP34: EDGE_DET_LT_OUT; TestPoint_Pad_D1.0mm
TP35: EDGE_DET_RB; TestPoint_Pad_D1.0mm
TP36: EDGE_DET_RB_OUT; TestPoint_Pad_D1.0mm
TP37: EDGE_DET_RT; TestPoint_Pad_D1.0mm
TP38: EDGE_DET_RT_OUT; TestPoint_Pad_D1.0mm
TP39, TP40, TP41, TP42, TP47, TP56, TP59, TP60, TP61: GND; TestPoint_Pad_D1.0mm
TP43: SDA1; TestPoint_Pad_D1.0mm
TP44: SCL1; TestPoint_Pad_D1.0mm
TP45, TP54: +3V3; TestPoint_Pad_D1.0mm
TP46, TP48: IR_OUT; TestPoint_Pad_D1.0mm
TP49: CHG_ON_LED; TestPoint_Pad_D1.0mm
TP50: CHG_DONE_LED; TestPoint_Pad_D1.0mm
TP51: VCC; TestPoint_Pad_D1.0mm
TP52: START; TestPoint_Pad_D1.0mm
TP53, TP62: BLUE; TestPoint_Pad_D1.0mm
TP55, TP63: RED; TestPoint_Pad_D1.0mm
TP57: 3V3; TestPoint_Pad_D1.0mm
TP64: LED_WHITE; TestPoint_Pad_D1.0mm

Connections:
+3V3: J12.1, J13.3, J14.3, R61.1, R64.1, R65.1, R68.1, R69.1, R70.1, R71.1, R72.1, R77.2, R78.2, R80.1, TP45.1, TP54.1, TP57.1; also elsewhere on the board
+5V: BZ1.1 (-); also elsewhere on the board
/peripheral/BLUE: Q12.3 (C), R76.1, R81.1
/peripheral/RED: Q11.3 (C), R75.1, R82.1
BELL: R62.1; also elsewhere on the board
CHG_DONE_LED: J14.7, TP50.1; also elsewhere on the board
CHG_ON_LED: J14.8, TP49.1; also elsewhere on the board
EDGE_DET_LB: J10.5, R61.2, TP31.1; also elsewhere on the board
EDGE_DET_LT: J10.2, R65.2, TP33.1; also elsewhere on the board
EDGE_DET_RB: J11.5, R69.2, TP35.1; also elsewhere on the board
EDGE_DET_RT: J11.2, R71.2, TP37.1; also elsewhere on the board
GND: J10.3, J10.6, J10.7, J10.MP (MountPin), J11.3, J11.6, J11.MP (MountPin), J12.3, J13.10, J13.11, J13.MP (MountPin), J14.1, J14.MP (MountPin), Q10.2 (E), Q11.2 (E), Q12.2 (E), R66.2, R67.2, R74.2, TP39.1, TP40.1, TP41.1, TP42.1, TP47.1, TP56.1, TP58.1, TP59.1, TP60.1, TP61.1; also elsewhere on the board
IR_OUT: J13.6, J14.9, R77.1, R78.1, TP46.1, TP48.1; also elsewhere on the board
LED_BLUE: R73.1; also elsewhere on the board
LED_RED: R63.1; also elsewhere on the board
LED_WHITE: R79.1; also elsewhere on the board
unnamed: BZ1.2 (+), Q10.3 (C)
unnamed: J10.1, R68.2, TP34.1
unnamed: J10.4, R64.2, TP32.1
unnamed: J11.1, R72.2, TP38.1
unnamed: J11.4, R70.2, TP36.1
unnamed: J13.1, R87.2, TP44.1
unnamed: J13.2, R88.2, TP43.1
unnamed: J13.4, R75.2, TP63.1
unnamed: J13.5, R76.2, TP62.1
unnamed: J14.4, R81.2, TP53.1
unnamed: J14.5, R82.2, TP55.1
unnamed: J14.6, R79.2, TP64.1
unnamed: Q10.1 (B), R62.2, R66.1
unnamed: Q11.1 (B), R63.2, R67.1
unnamed: Q12.1 (B), R73.2, R74.1
SCL1: R87.1; also elsewhere on the board
SDA1: R88.1; also elsewhere on the board
START: J14.2, R80.2, TP52.1; also elsewhere on the board
SWCLK: J12.4, J13.8, TP2.1; also elsewhere on the board
SWDIO: J12.2, J13.7, TP1.1; also elsewhere on the board
UART2_RX: J12.5, J13.9, TP3.1; also elsewhere on the board
VCC: J14.10, TP51.1; also elsewhere on the board

Notes on the sheet:
带气压功能需要R87,R88电阻

Parts:
C20, C37: 100uF/35V; CP_Elec_6.3x7.7
C21, C26, C28, C32, C63: 1uF; C_0603_1608Metric
C22, C24: 10uF; C_0603_1608Metric
C23, C25, C35, C36: 0.1uF; C_0603_1608Metric
C27: 220nF; C_0603_1608Metric
C29: 1nF; C_0603_1608Metric
C30: 1.5pF; C_0603_1608Metric
C33, C62: 10uF/35V; C_0805_2012Metric
C34: 0.1uF; C_0603_1608Metric; not fitted
C64: 470uF/10V; CP_Elec_6.3x7.7
C65: 3.3nF; C_0603_1608Metric
D1, D4, D5: SS14; D_SOD-123
D2, D9: SMAJ24CA; D_SMA
D6, D7, D8, D14: SS34; D_SMA
J1: PH2.0MM/2ASMT; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J2: PH2.0MM/3ASMT; JST_PH_B3B-PH-SM4-TB_1x03-1MP_P2.00mm_Vertical
L1: 120R@100MHz/3A; L_1206_3216Metric
L3: 100uH; L_GZJ_WNR6045
L10: 68uH; L_GZJ_CD75
Q1: HSS6107; SOT-23
Q2: SI2302; SOT-23; not fitted
Q3: SS8050; SOT-23
Q4: NCE4435; SOIC-8_3.9x4.9mm_P1.27mm
R11, R12, R23, R24, R25: 10K/1%; R_0603_1608Metric
R13: 51R; R_0603_1608Metric
R14: 120R; R_0603_1608Metric
R15, R19: 0R; R_0603_1608Metric
R16: 1.5M/1%; R_0603_1608Metric
R17: 120K/1%; R_0603_1608Metric
R18: 100R; R_0603_1608Metric
R20: 0.5R/1%; R_1206_3216Metric
R21, R85: 1K/1%; R_0603_1608Metric
R22: 10K/1%; R_0603_1608Metric; not fitted
R26, R28: 1M/1%; R_0603_1608Metric
R27, R29: 100K/1%; R_0603_1608Metric
R86: 5.6K/1%; R_0603_1608Metric
TP6, TP7: 24V; TestPoint_Pad_D1.0mm
TP8: BATT; TestPoint_Pad_D1.0mm
TP9: TEMP; TestPoint_Pad_D1.0mm
U7: DS8562-33S5; SOT-23-5
U8: CN3765; SSOP-10_3.9x4.9mm_P1.00mm
U9: AMS1117-5.0; SOT-223-3_TabPin2
U16: XL1509-ADJ; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C32.1, R19.2; also elsewhere on the board
+3.3VP: R15.2; also elsewhere on the board
+3V3: C26.1, C28.1, R15.1, R19.1, R22.1, U7.5 (VOUT); also elsewhere on the board
+5V: C21.1, C24.1, U7.1 (VIN), U7.3 (EN), U9.2 (VO); also elsewhere on the board
+24V: D1.2 (A), D6.2 (A), D7.2 (A), J1.1, TP6.1, TP7.1
+BATT: J2.3, Q4.1 (S), Q4.2 (S), Q4.3 (S), R24.2, TP8.1
/power/BATT_CHRG: C30.1, C33.1, D8.2 (A), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), R16.1, R20.2, R26.1, U8.7 (BAT)
ADC_BATT: C35.1, R26.2, R27.1; also elsewhere on the board
ADC_CHG_DET: C36.1, R28.2, R29.1; also elsewhere on the board
BATT_ON: R21.2; also elsewhere on the board
CHG_DONE_LED: R12.1; also elsewhere on the board
CHG_ON_LED: R11.1; also elsewhere on the board
EN_CHRG: Q2.1 (G); also elsewhere on the board
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C29.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C62.2, C63.2, C64.2, D2.2 (A), D5.2 (A), D9.2 (A), D14.2 (A), J1.2, J1.MP (MountPin), J2.2, J2.MP (MountPin), Q2.2 (S), Q3.2 (E), R17.2, R23.1, R27.2, R29.2, R85.1, U7.2 (GND), U8.2 (GND), U9.1 (GND), U16.4 (EN), U16.5 (GND), U16.6 (GND), U16.7 (GND), U16.8 (GND); also elsewhere on the board
unnamed: C27.1, R14.2
unnamed: C29.1, R18.2
unnamed: D4.2 (A), L1.2
unnamed: D4.1 (K), D5.1 (K), L3.1, R18.1
unnamed: D14.1 (K), L10.1, U16.2 (OUT)
unnamed: L1.1, Q1.3 (D)
unnamed: Q1.1 (G), R13.1
unnamed: Q2.3 (D), R14.1, U8.5 (COM)
unnamed: Q3.1 (B), R21.1, R23.2
unnamed: Q3.3 (C), R25.1
unnamed: Q4.4 (G), R24.1, R25.2
unnamed: L3.2, R20.1, U8.8 (CSP)
unnamed: R13.2, U8.10 (DRV)
unnamed: C30.2, R16.2, R17.1, U8.6 (FB)
unnamed: C25.2, U8.1 (VG)
unnamed: R11.2, U8.3 (~CHRG)
unnamed: R12.2, U8.4 (~DONE)
unnamed: C65.1, R85.2, R86.1, U16.3 (FB)
TEMP: C34.1, J2.1, R22.2, TP9.1; also elsewhere on the board
VCC: C20.1, C23.1, C25.1, D1.1 (K), D2.1 (K), Q1.2 (S), U8.9 (VCC); also elsewhere on the board
VCC_ADJ: C22.1, C64.1, C65.2, L10.2, R86.2, U9.3 (VI); also elsewhere on the board
VDD: C37.1, C62.1, C63.1, D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), R28.1, U16.1 (VIN); also elsewhere on the board

Notes on the sheet:
CN3705 220K/1% CN3704 0R
Vout=1.23(1+R86/R85)
L=开启充电 H=关闭充电 x=开启充电

Parts:
C50: 10uF; C_0603_1608Metric
C51, C53, C55, C56, C58, C59: 1uF; C_0603_1608Metric
C52: 1nF; C_0603_1608Metric
C54: 0.47uF; C_0603_1608Metric
C57: 470uF/10V; CP_Elec_6.3x7.7
C60, C61: 0.1uF; C_0603_1608Metric
D12, D13: SS14; D_SOD-123; not fitted
F1: MF-PSMF050X; Fuse_0805_2012Metric
J6, J7, J8, J9: ZH1.5MM/2ASMT; JST_ZH_B2B-ZR-SM4-TF_1x02-1MP_P1.50mm_Vertical
L8, L9: 10/500uH; L_WLJ_CD0805
Q7: SS8050; SOT-23
Q8, Q9: CJ2310; SOT-23
Q13: SI2301; SOT-23
R51: 0R; R_0603_1608Metric
R52, R54: 470R; R_0603_1608Metric
R53, R55, R59, R60, R90: 10K/1%; R_0603_1608Metric
R56: 12K/1%; R_0603_1608Metric
R57, R58, R89: 1K/1%; R_0603_1608Metric
R83, R84: 0R; R_0603_1608Metric; not fitted
TP17: DO; TestPoint_Pad_D1.0mm
TP18: CLK; TestPoint_Pad_D1.0mm
TP19: DI; TestPoint_Pad_D1.0mm
TP20: CS; TestPoint_Pad_D1.0mm
TP21: 3V3; TestPoint_Pad_D1.0mm
TP22: GND; TestPoint_Pad_D1.0mm
TP23: WATER_DET_P; TestPoint_Pad_D1.0mm
TP24: WATER_DET_N; TestPoint_Pad_D1.0mm
TP25: SPEAKER_P; TestPoint_Pad_D1.0mm
TP26: SPEAKER_N; TestPoint_Pad_D1.0mm
TP27: SPRAY_BACK_P; TestPoint_Pad_D1.0mm
TP28: SPRAY_BACK_N; TestPoint_Pad_D1.0mm
TP29: SPRAY_FRONT_P; TestPoint_Pad_D1.0mm
TP30: SPRAY_FRONT_N; TestPoint_Pad_D1.0mm
U14: WT588F02B-8S-B2(EGS-01); SOIC-8_3.9x4.9mm_P1.27mm
U15: 8002A; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C50.1, Q13.2 (S), R90.1, TP21.1, U14.6 (VDD); also elsewhere on the board
+5V: C56.1, U15.6 (VDD); also elsewhere on the board
/pump/VOICE_BUSY: R53.1, TP20.1, U14.1 (PC2/CS)
GND: C50.2, C51.2, C52.2, C53.2, C55.1, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, J6.MP (MountPin), J7.MP (MountPin), J8.MP (MountPin), J9.MP (MountPin), Q8.2 (S), Q9.2 (S), R52.2, R59.2, R60.2, TP22.1, U14.8 (GND), U15.7 (GND); also elsewhere on the board
unnamed: C54.2, R55.1
unnamed: C57.1, C58.1, C59.1, C60.1, C61.1, F1.2, L8.1, L9.1
unnamed: D12.2 (A), J8.2, L8.2, Q8.3 (D), TP28.1
unnamed: D12.1 (K), J8.1, L8.3, R84.1, TP27.1
unnamed: D13.2 (A), J9.2, L9.2, Q9.3 (D), TP30.1
unnamed: D13.1 (K), J9.1, L9.3, R83.1, TP29.1
unnamed: J6.1, R54.2, TP23.1
unnamed: J6.2, Q7.1 (B), TP24.1
unnamed: J7.1, TP26.1, U15.8 (VO2)
unnamed: J7.2, R56.2, TP25.1, U15.5 (VO1)
unnamed: Q8.1 (G), R57.2, R59.1
unnamed: Q9.1 (G), R58.2, R60.1
unnamed: Q7.3 (C), Q13.3 (D), R54.1
unnamed: Q13.1 (G), R89.2, R90.2
unnamed: R51.2, U14.2 (PC1/SO)
unnamed: TP19.1, U14.3 (PI0/SI)
unnamed: TP18.1, U14.4 (PI1/SCK)
unnamed: C52.1, U14.5 (PWMN)
unnamed: C54.1, U14.7 (PWMP/DAC)
unnamed: C55.2, U15.2 (BYPASS), U15.3 (IN+)
unnamed: R55.2, R56.1, U15.4 (IN-)
unnamed: C53.1, R53.2, U15.1 (~SD)
SPRAY_BACK: R57.1; also elsewhere on the board
SPRAY_FRONT: R58.1; also elsewhere on the board
VCC_ADJ: F1.1, R84.2; also elsewhere on the board
VDD: R83.2; also elsewhere on the board
VOICE_DATA: R51.1, TP17.1; also elsewhere on the board
WATER_3.3VSW: R89.1; also elsewhere on the board
WATER_DET: C51.1, Q7.2 (E), R52.1; also elsewhere on the board

Parts:
C31, C39, C66: 100uF/35V; CP_Elec_6.3x7.7
C38, C40, C41, C42, C43, C44, C45, C46, C47, C48: 0.1uF; C_0603_1608Metric
C49: 10nF; C_0603_1608Metric
D10: 1N4004; D_SMA; not fitted
D11: 1N4004; D_SMA
J3, J4: PH2.0MM/2ASMT; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J5: PH2.0MM/3ASMT; JST_PH_B3B-PH-SM4-TB_1x03-1MP_P2.00mm_Vertical
L4, L5, L6, L7: 120R@100MHz/3A; L_1206_3216Metric
Q5: SS8050; SOT-23
Q6: NCE4435; SOIC-8_3.9x4.9mm_P1.27mm; not fitted
R30: 4.7K/1%; R_0603_1608Metric
R31: 3.3K/1%; R_0603_1608Metric
R32: 1K/1%; R_0603_1608Metric
R33, R49: 10K/1%; R_0603_1608Metric
R34, R35: 680R; R_0603_1608Metric; not fitted
R36: 0R; R_0603_1608Metric
R37, R38: 0.033R/1%(1W); R_1206_3216Metric
R39, R40, R45: 15K/1%; R_0603_1608Metric
R41, R42, R43, R44: 0.1R; R_0805_2012Metric
R46, R47, R48: 51K/1%; R_0603_1608Metric
R50: 2K/1%; R_0603_1608Metric
TP10: MOTOR_LEFT_OUT_N; TestPoint_Pad_D1.0mm
TP11: MOTOR_RIGHT_OUT_N; TestPoint_Pad_D1.0mm
TP12: MOTOR_LEFT_OUT_P; TestPoint_Pad_D1.0mm
TP13: MOTOR_RIGHT_OUT_P; TestPoint_Pad_D1.0mm
TP14: VDD; TestPoint_Pad_D1.0mm
TP15: FAN_PWM; TestPoint_Pad_D1.0mm
TP16: FAN_OUT_N; TestPoint_Pad_D1.0mm
U10, U11: DRV8870DDAR; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
U12, U13: LMV358TP-SR; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3VA: C45.1, C47.1, R49.1, U12.8 (V+), U13.8 (V+); also elsewhere on the board
+3V3: R30.1; also elsewhere on the board
/driver/VREF55: C48.1, C49.1, U12.3 (+), U12.5 (+), U13.3 (+), U13.6 (-), U13.7
ADC_FAN_MOTOR: C44.2, R48.2, U13.1; also elsewhere on the board
ADC_LEFT_MOTOR: C42.2, R46.2, U12.1; also elsewhere on the board
ADC_RIGHT_MOTOR: C43.2, R47.2, U12.7; also elsewhere on the board
GND: C31.2, C38.2, C39.2, C40.2, C41.2, C45.2, C46.2, C47.2, C48.2, C49.2, C66.2, D10.2 (A), J3.MP (MountPin), J4.MP (MountPin), J5.MP (MountPin), Q5.2 (E), R31.2, R33.1, R37.2, R38.2, R41.2, R42.2, R43.2, R44.2, R50.2, U10.1 (GND), U10.9 (GND), U11.1 (GND), U11.9 (GND), U12.4 (V-), U13.4 (V-); also elsewhere on the board
unnamed: D10.1 (K), J5.3, Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), R36.2, TP15.1
unnamed: D11.2 (A), J5.2, R41.1, R42.1, R43.1, R44.1, R45.1, TP16.1
unnamed: J3.1, L5.2, TP10.1
unnamed: J3.2, L4.2, TP12.1
unnamed: J4.1, L7.2, TP11.1
unnamed: J4.2, L6.2, TP13.1
unnamed: Q5.1 (B), R32.2, R33.2
unnamed: Q5.3 (C), R35.2, R36.1
unnamed: Q6.4 (G), R34.2, R35.1
unnamed: R37.1, R39.1, U10.7 (ISEN)
unnamed: L4.1, U10.6 (OUT1)
unnamed: L5.1, U10.8 (OUT2)
unnamed: C38.1, R30.2, R31.1, U10.4 (VREF), U11.4 (VREF)
unnamed: R38.1, R40.1, U11.7 (ISEN)
unnamed: L6.1, U11.6 (OUT1)
unnamed: L7.1, U11.8 (OUT2)
unnamed: C42.1, R39.2, R46.1, U12.2 (-)
unnamed: C43.1, R40.2, R47.1, U12.6 (-)
unnamed: C44.1, R45.2, R48.1, U13.2 (-)
unnamed: C46.1, R49.2, R50.1, U13.5 (+)
PWM_FAN: R32.1; also elsewhere on the board
PWM_LEFT1: U10.3 (IN1); also elsewhere on the board
PWM_LEFT2: U10.2 (IN2); also elsewhere on the board
PWM_RIGHT1: U11.3 (IN1); also elsewhere on the board
PWM_RIGHT2: U11.2 (IN2); also elsewhere on the board
VDD: C31.1, C39.1, C40.1, C41.1, C66.1, D11.1 (K), J5.1, Q6.1 (S), Q6.2 (S), Q6.3 (S), R34.1, TP14.1, U10.5 (VM), U11.5 (VM); also elsewhere on the board
